v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
N 17040 3060 17210 3060 {lab=_0_[0]}
C {devices/lab_wire.sym} 17040 3060 0 0 {lab=_0_[0]}
N 17290 3060 17500 3060 {lab=clockp[0]}
C {devices/lab_wire.sym} 17290 3060 0 0 {lab=clockp[0]}
N 8540 2500 8710 2500 {lab=_0_[1]}
C {devices/lab_wire.sym} 8540 2500 0 0 {lab=_0_[1]}
N 8790 2500 9000 2500 {lab=clockp[1]}
C {devices/lab_wire.sym} 8790 2500 0 0 {lab=clockp[1]}
N 16540 3910 8620 3910 {lab=\\dstage[0].id.in\\}
N 8620 3910 8620 380 {lab=\\dstage[0].id.in\\}
N 8620 380 940 380 {lab=\\dstage[0].id.in\\}
N 940 380 940 360 {lab=\\dstage[0].id.in\\}
N 940 360 1060 360 {lab=\\dstage[0].id.in\\}
N 1060 360 1060 3000 {lab=\\dstage[0].id.in\\}
N 1060 3000 710 3000 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 16540 3910 0 0 {lab=\\dstage[0].id.in\\}
N 540 3840 640 3840 {lab=\\dstage[0].id.in\\}
N 640 3840 640 3000 {lab=\\dstage[0].id.in\\}
N 640 3000 710 3000 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 540 3840 0 0 {lab=\\dstage[0].id.in\\}
N 540 1430 620 1430 {lab=\\dstage[0].id.in\\}
N 620 1430 620 3000 {lab=\\dstage[0].id.in\\}
N 620 3000 710 3000 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 540 1430 0 0 {lab=\\dstage[0].id.in\\}
N 16540 3910 16620 3910 {lab=\\dstage[0].id.in\\}
N 16620 3910 16620 3060 {lab=\\dstage[0].id.in\\}
N 16620 3060 16710 3060 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 16540 3910 0 0 {lab=\\dstage[0].id.in\\}
N 540 3840 8620 3840 {lab=\\dstage[0].id.in\\}
N 8620 3840 8620 3060 {lab=\\dstage[0].id.in\\}
N 8620 3060 16710 3060 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 540 3840 0 0 {lab=\\dstage[0].id.in\\}
N 540 1430 8640 1430 {lab=\\dstage[0].id.in\\}
N 8640 1430 8640 3060 {lab=\\dstage[0].id.in\\}
N 8640 3060 16710 3060 {lab=\\dstage[0].id.in\\}
C {devices/lab_wire.sym} 540 1430 0 0 {lab=\\dstage[0].id.in\\}
N 790 3000 960 3000 {lab=\\dstage[0].id.ts\\}
C {devices/lab_wire.sym} 790 3000 0 0 {lab=\\dstage[0].id.ts\\}
N 790 3000 960 3000 {lab=\\dstage[0].id.ts\\}
C {devices/lab_wire.sym} 790 3000 0 0 {lab=\\dstage[0].id.ts\\}
N 790 3000 960 3000 {lab=\\dstage[0].id.ts\\}
C {devices/lab_wire.sym} 790 3000 0 0 {lab=\\dstage[0].id.ts\\}
N 1040 3000 940 3000 {lab=\\dstage[0].id.d0\\}
N 940 3000 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d0\\}
N 940 380 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 1120 380 {lab=\\dstage[0].id.d0\\}
N 1120 380 1120 2680 {lab=\\dstage[0].id.d0\\}
N 1120 2680 1210 2680 {lab=\\dstage[0].id.d0\\}
C {devices/lab_wire.sym} 1040 3000 0 0 {lab=\\dstage[0].id.d0\\}
N 1540 2840 1620 2840 {lab=\\dstage[0].id.d2\\}
N 1620 2840 1620 2020 {lab=\\dstage[0].id.d2\\}
N 1620 2020 1710 2020 {lab=\\dstage[0].id.d2\\}
C {devices/lab_wire.sym} 1540 2840 0 0 {lab=\\dstage[0].id.d2\\}
N 250 1210 980 1210 {lab=trim[0]}
N 980 1210 980 2060 {lab=trim[0]}
N 980 2060 1710 2060 {lab=trim[0]}
C {devices/lab_wire.sym} 250 1210 0 0 {lab=trim[0]}
N 1790 2020 1880 2020 {lab=\\dstage[0].id.out\\}
N 1880 2020 1880 2510 {lab=\\dstage[0].id.out\\}
N 1880 2510 1960 2510 {lab=\\dstage[0].id.out\\}
C {devices/lab_wire.sym} 1790 2020 0 0 {lab=\\dstage[0].id.out\\}
N 1040 3000 940 3000 {lab=\\dstage[0].id.out\\}
N 940 3000 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 940 380 {lab=\\dstage[0].id.out\\}
N 940 380 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 1500 380 {lab=\\dstage[0].id.out\\}
N 1500 380 1500 2510 {lab=\\dstage[0].id.out\\}
N 1500 2510 1960 2510 {lab=\\dstage[0].id.out\\}
C {devices/lab_wire.sym} 1040 3000 0 0 {lab=\\dstage[0].id.out\\}
N 250 2350 730 2350 {lab=trim[13]}
N 730 2350 730 2720 {lab=trim[13]}
N 730 2720 1210 2720 {lab=trim[13]}
C {devices/lab_wire.sym} 250 2350 0 0 {lab=trim[13]}
N 1290 2680 1380 2680 {lab=\\dstage[0].id.d1\\}
N 1380 2680 1380 2840 {lab=\\dstage[0].id.d1\\}
N 1380 2840 1460 2840 {lab=\\dstage[0].id.d1\\}
C {devices/lab_wire.sym} 1290 2680 0 0 {lab=\\dstage[0].id.d1\\}
N 1040 3000 940 3000 {lab=\\dstage[0].id.d1\\}
N 940 3000 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d1\\}
N 940 380 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 1250 380 {lab=\\dstage[0].id.d1\\}
N 1250 380 1250 2840 {lab=\\dstage[0].id.d1\\}
N 1250 2840 1460 2840 {lab=\\dstage[0].id.d1\\}
C {devices/lab_wire.sym} 1040 3000 0 0 {lab=\\dstage[0].id.d1\\}
N 13040 3590 13120 3590 {lab=\\dstage[10].id.in\\}
N 13120 3590 13120 3360 {lab=\\dstage[10].id.in\\}
N 13120 3360 13210 3360 {lab=\\dstage[10].id.in\\}
C {devices/lab_wire.sym} 13040 3590 0 0 {lab=\\dstage[10].id.in\\}
N 12290 3130 12190 3130 {lab=\\dstage[10].id.in\\}
N 12190 3130 12190 3060 {lab=\\dstage[10].id.in\\}
N 12190 3060 12310 3060 {lab=\\dstage[10].id.in\\}
N 12310 3060 12310 3080 {lab=\\dstage[10].id.in\\}
N 12310 3080 12190 3080 {lab=\\dstage[10].id.in\\}
N 12190 3080 12190 3060 {lab=\\dstage[10].id.in\\}
N 12190 3060 12310 3060 {lab=\\dstage[10].id.in\\}
N 12310 3060 12310 3080 {lab=\\dstage[10].id.in\\}
N 12310 3080 12750 3080 {lab=\\dstage[10].id.in\\}
N 12750 3080 12750 3360 {lab=\\dstage[10].id.in\\}
N 12750 3360 13210 3360 {lab=\\dstage[10].id.in\\}
C {devices/lab_wire.sym} 12290 3130 0 0 {lab=\\dstage[10].id.in\\}
N 13290 3360 13460 3360 {lab=\\dstage[10].id.ts\\}
C {devices/lab_wire.sym} 13290 3360 0 0 {lab=\\dstage[10].id.ts\\}
N 13290 3360 13460 3360 {lab=\\dstage[10].id.ts\\}
C {devices/lab_wire.sym} 13290 3360 0 0 {lab=\\dstage[10].id.ts\\}
N 13290 3360 13460 3360 {lab=\\dstage[10].id.ts\\}
C {devices/lab_wire.sym} 13290 3360 0 0 {lab=\\dstage[10].id.ts\\}
N 13540 3360 13440 3360 {lab=\\dstage[10].id.d0\\}
N 13440 3360 13440 3320 {lab=\\dstage[10].id.d0\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d0\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d0\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.d0\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d0\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d0\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d0\\}
N 13560 3340 13620 3340 {lab=\\dstage[10].id.d0\\}
N 13620 3340 13620 4220 {lab=\\dstage[10].id.d0\\}
N 13620 4220 13710 4220 {lab=\\dstage[10].id.d0\\}
C {devices/lab_wire.sym} 13540 3360 0 0 {lab=\\dstage[10].id.d0\\}
N 14040 3790 14120 3790 {lab=\\dstage[10].id.d2\\}
N 14120 3790 14120 3840 {lab=\\dstage[10].id.d2\\}
N 14120 3840 14210 3840 {lab=\\dstage[10].id.d2\\}
C {devices/lab_wire.sym} 14040 3790 0 0 {lab=\\dstage[10].id.d2\\}
N 250 3890 7230 3890 {lab=trim[10]}
N 7230 3890 7230 3880 {lab=trim[10]}
N 7230 3880 14210 3880 {lab=trim[10]}
C {devices/lab_wire.sym} 250 3890 0 0 {lab=trim[10]}
N 14290 3840 14380 3840 {lab=\\dstage[10].id.out\\}
N 14380 3840 14380 3600 {lab=\\dstage[10].id.out\\}
N 14380 3600 14460 3600 {lab=\\dstage[10].id.out\\}
C {devices/lab_wire.sym} 14290 3840 0 0 {lab=\\dstage[10].id.out\\}
N 13540 3360 13440 3360 {lab=\\dstage[10].id.out\\}
N 13440 3360 13440 3320 {lab=\\dstage[10].id.out\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.out\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.out\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.out\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.out\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.out\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.out\\}
N 13560 3340 14000 3340 {lab=\\dstage[10].id.out\\}
N 14000 3340 14000 3600 {lab=\\dstage[10].id.out\\}
N 14000 3600 14460 3600 {lab=\\dstage[10].id.out\\}
C {devices/lab_wire.sym} 13540 3360 0 0 {lab=\\dstage[10].id.out\\}
N 250 5080 6980 5080 {lab=trim[23]}
N 6980 5080 6980 4260 {lab=trim[23]}
N 6980 4260 13710 4260 {lab=trim[23]}
C {devices/lab_wire.sym} 250 5080 0 0 {lab=trim[23]}
N 13790 4220 13880 4220 {lab=\\dstage[10].id.d1\\}
N 13880 4220 13880 3790 {lab=\\dstage[10].id.d1\\}
N 13880 3790 13960 3790 {lab=\\dstage[10].id.d1\\}
C {devices/lab_wire.sym} 13790 4220 0 0 {lab=\\dstage[10].id.d1\\}
N 13540 3360 13440 3360 {lab=\\dstage[10].id.d1\\}
N 13440 3360 13440 3320 {lab=\\dstage[10].id.d1\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d1\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d1\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.d1\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d1\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d1\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d1\\}
N 13560 3340 13750 3340 {lab=\\dstage[10].id.d1\\}
N 13750 3340 13750 3790 {lab=\\dstage[10].id.d1\\}
N 13750 3790 13960 3790 {lab=\\dstage[10].id.d1\\}
C {devices/lab_wire.sym} 13540 3360 0 0 {lab=\\dstage[10].id.d1\\}
N 14540 3600 14710 3600 {lab=\\dstage[11].id.ts\\}
C {devices/lab_wire.sym} 14540 3600 0 0 {lab=\\dstage[11].id.ts\\}
N 14540 3600 7380 3600 {lab=\\dstage[11].id.ts\\}
N 7380 3600 7380 250 {lab=\\dstage[11].id.ts\\}
N 7380 250 440 250 {lab=\\dstage[11].id.ts\\}
N 440 250 440 230 {lab=\\dstage[11].id.ts\\}
N 440 230 560 230 {lab=\\dstage[11].id.ts\\}
N 560 230 560 3590 {lab=\\dstage[11].id.ts\\}
N 560 3590 210 3590 {lab=\\dstage[11].id.ts\\}
C {devices/lab_wire.sym} 14540 3600 0 0 {lab=\\dstage[11].id.ts\\}
N 14540 3600 14710 3600 {lab=\\dstage[11].id.ts\\}
C {devices/lab_wire.sym} 14540 3600 0 0 {lab=\\dstage[11].id.ts\\}
N 14790 3600 14690 3600 {lab=\\dstage[11].id.d0\\}
N 14690 3600 14690 3570 {lab=\\dstage[11].id.d0\\}
N 14690 3570 14810 3570 {lab=\\dstage[11].id.d0\\}
N 14810 3570 14810 3590 {lab=\\dstage[11].id.d0\\}
N 14810 3590 14880 3590 {lab=\\dstage[11].id.d0\\}
N 14880 3590 14880 4470 {lab=\\dstage[11].id.d0\\}
N 14880 4470 14960 4470 {lab=\\dstage[11].id.d0\\}
C {devices/lab_wire.sym} 14790 3600 0 0 {lab=\\dstage[11].id.d0\\}
N 15290 4030 15380 4030 {lab=\\dstage[11].id.d2\\}
N 15380 4030 15380 4090 {lab=\\dstage[11].id.d2\\}
N 15380 4090 15460 4090 {lab=\\dstage[11].id.d2\\}
C {devices/lab_wire.sym} 15290 4030 0 0 {lab=\\dstage[11].id.d2\\}
N 250 4140 7860 4140 {lab=trim[11]}
N 7860 4140 7860 4130 {lab=trim[11]}
N 7860 4130 15460 4130 {lab=trim[11]}
C {devices/lab_wire.sym} 250 4140 0 0 {lab=trim[11]}
N 15540 4090 15660 4090 {lab=\\dstage[11].id.out\\}
N 15660 4090 15660 2170 {lab=\\dstage[11].id.out\\}
N 15660 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 3840 {lab=\\dstage[11].id.out\\}
N 15810 3840 15710 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 15540 4090 0 0 {lab=\\dstage[11].id.out\\}
N 15540 4090 7980 4090 {lab=\\dstage[11].id.out\\}
N 7980 4090 7940 4100 {lab=\\dstage[11].id.out\\}
N 7940 4100 7940 2550 {lab=\\dstage[11].id.out\\}
N 7940 2550 8060 2550 {lab=\\dstage[11].id.out\\}
N 8060 2550 8060 250 {lab=\\dstage[11].id.out\\}
N 8060 250 7980 3840 {lab=\\dstage[11].id.out\\}
N 7980 3840 460 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 15540 4090 0 0 {lab=\\dstage[11].id.out\\}
N 15540 4090 15600 4090 {lab=\\dstage[11].id.out\\}
N 15600 4090 15600 2170 {lab=\\dstage[11].id.out\\}
N 15600 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 3840 {lab=\\dstage[11].id.out\\}
N 15810 3840 15710 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 15540 4090 0 0 {lab=\\dstage[11].id.out\\}
N 290 3590 440 3590 {lab=\\dstage[11].id.out\\}
N 440 3590 440 230 {lab=\\dstage[11].id.out\\}
N 440 230 560 230 {lab=\\dstage[11].id.out\\}
N 560 230 560 250 {lab=\\dstage[11].id.out\\}
N 560 250 8040 250 {lab=\\dstage[11].id.out\\}
N 8040 250 8040 2170 {lab=\\dstage[11].id.out\\}
N 8040 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 3840 {lab=\\dstage[11].id.out\\}
N 15810 3840 15710 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 290 3590 0 0 {lab=\\dstage[11].id.out\\}
N 290 3590 380 3590 {lab=\\dstage[11].id.out\\}
N 380 3590 380 3840 {lab=\\dstage[11].id.out\\}
N 380 3840 460 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 290 3590 0 0 {lab=\\dstage[11].id.out\\}
N 290 3590 440 3590 {lab=\\dstage[11].id.out\\}
N 440 3590 440 230 {lab=\\dstage[11].id.out\\}
N 440 230 560 230 {lab=\\dstage[11].id.out\\}
N 560 230 560 250 {lab=\\dstage[11].id.out\\}
N 560 250 7980 250 {lab=\\dstage[11].id.out\\}
N 7980 250 7980 2170 {lab=\\dstage[11].id.out\\}
N 7980 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 3840 {lab=\\dstage[11].id.out\\}
N 15810 3840 15710 3840 {lab=\\dstage[11].id.out\\}
C {devices/lab_wire.sym} 290 3590 0 0 {lab=\\dstage[11].id.out\\}
N 250 5340 7600 5340 {lab=trim[24]}
N 7600 5340 7600 4510 {lab=trim[24]}
N 7600 4510 14960 4510 {lab=trim[24]}
C {devices/lab_wire.sym} 250 5340 0 0 {lab=trim[24]}
N 15040 4470 15120 4470 {lab=\\dstage[11].id.d1\\}
N 15120 4470 15120 4030 {lab=\\dstage[11].id.d1\\}
N 15120 4030 15210 4030 {lab=\\dstage[11].id.d1\\}
C {devices/lab_wire.sym} 15040 4470 0 0 {lab=\\dstage[11].id.d1\\}
N 14790 3600 14690 3600 {lab=\\dstage[11].id.d1\\}
N 14690 3600 14690 3570 {lab=\\dstage[11].id.d1\\}
N 14690 3570 14810 3570 {lab=\\dstage[11].id.d1\\}
N 14810 3570 14810 3590 {lab=\\dstage[11].id.d1\\}
N 14810 3590 15000 3590 {lab=\\dstage[11].id.d1\\}
N 15000 3590 15000 4030 {lab=\\dstage[11].id.d1\\}
N 15000 4030 15210 4030 {lab=\\dstage[11].id.d1\\}
C {devices/lab_wire.sym} 14790 3600 0 0 {lab=\\dstage[11].id.d1\\}
N 2040 2510 2210 2510 {lab=\\dstage[1].id.ts\\}
C {devices/lab_wire.sym} 2040 2510 0 0 {lab=\\dstage[1].id.ts\\}
N 2040 2510 2210 2510 {lab=\\dstage[1].id.ts\\}
C {devices/lab_wire.sym} 2040 2510 0 0 {lab=\\dstage[1].id.ts\\}
N 2040 2510 2210 2510 {lab=\\dstage[1].id.ts\\}
C {devices/lab_wire.sym} 2040 2510 0 0 {lab=\\dstage[1].id.ts\\}
N 2290 2510 2190 2510 {lab=\\dstage[1].id.d0\\}
N 2190 2510 2190 750 {lab=\\dstage[1].id.d0\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d0\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d0\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.d0\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d0\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d0\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d0\\}
N 2310 770 2380 770 {lab=\\dstage[1].id.d0\\}
N 2380 770 2380 2590 {lab=\\dstage[1].id.d0\\}
N 2380 2590 2460 2590 {lab=\\dstage[1].id.d0\\}
C {devices/lab_wire.sym} 2290 2510 0 0 {lab=\\dstage[1].id.d0\\}
N 2790 2550 2880 2550 {lab=\\dstage[1].id.d2\\}
N 2880 2550 2880 2030 {lab=\\dstage[1].id.d2\\}
N 2880 2030 2960 2030 {lab=\\dstage[1].id.d2\\}
C {devices/lab_wire.sym} 2790 2550 0 0 {lab=\\dstage[1].id.d2\\}
N 250 1520 1600 1520 {lab=trim[1]}
N 1600 1520 1600 2070 {lab=trim[1]}
N 1600 2070 2960 2070 {lab=trim[1]}
C {devices/lab_wire.sym} 250 1520 0 0 {lab=trim[1]}
N 3040 2030 3120 2030 {lab=\\dstage[1].id.out\\}
N 3120 2030 3120 2270 {lab=\\dstage[1].id.out\\}
N 3120 2270 3210 2270 {lab=\\dstage[1].id.out\\}
C {devices/lab_wire.sym} 3040 2030 0 0 {lab=\\dstage[1].id.out\\}
N 2290 2510 2190 2510 {lab=\\dstage[1].id.out\\}
N 2190 2510 2190 750 {lab=\\dstage[1].id.out\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.out\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.out\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.out\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.out\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.out\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.out\\}
N 2310 770 2750 770 {lab=\\dstage[1].id.out\\}
N 2750 770 2750 2270 {lab=\\dstage[1].id.out\\}
N 2750 2270 3210 2270 {lab=\\dstage[1].id.out\\}
C {devices/lab_wire.sym} 2290 2510 0 0 {lab=\\dstage[1].id.out\\}
N 250 2680 1360 2680 {lab=trim[14]}
N 1360 2680 1360 2630 {lab=trim[14]}
N 1360 2630 2460 2630 {lab=trim[14]}
C {devices/lab_wire.sym} 250 2680 0 0 {lab=trim[14]}
N 2540 2590 2620 2590 {lab=\\dstage[1].id.d1\\}
N 2620 2590 2620 2550 {lab=\\dstage[1].id.d1\\}
N 2620 2550 2710 2550 {lab=\\dstage[1].id.d1\\}
C {devices/lab_wire.sym} 2540 2590 0 0 {lab=\\dstage[1].id.d1\\}
N 2290 2510 2190 2510 {lab=\\dstage[1].id.d1\\}
N 2190 2510 2190 750 {lab=\\dstage[1].id.d1\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d1\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d1\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.d1\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d1\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d1\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d1\\}
N 2310 770 2500 770 {lab=\\dstage[1].id.d1\\}
N 2500 770 2500 2550 {lab=\\dstage[1].id.d1\\}
N 2500 2550 2710 2550 {lab=\\dstage[1].id.d1\\}
C {devices/lab_wire.sym} 2290 2510 0 0 {lab=\\dstage[1].id.d1\\}
N 3290 2270 3460 2270 {lab=\\dstage[2].id.ts\\}
C {devices/lab_wire.sym} 3290 2270 0 0 {lab=\\dstage[2].id.ts\\}
N 3290 2270 3460 2270 {lab=\\dstage[2].id.ts\\}
C {devices/lab_wire.sym} 3290 2270 0 0 {lab=\\dstage[2].id.ts\\}
N 3290 2270 3460 2270 {lab=\\dstage[2].id.ts\\}
C {devices/lab_wire.sym} 3290 2270 0 0 {lab=\\dstage[2].id.ts\\}
N 3540 2270 3440 2270 {lab=\\dstage[2].id.d0\\}
N 3440 2270 3440 1110 {lab=\\dstage[2].id.d0\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d0\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d0\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.d0\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d0\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d0\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d0\\}
N 3560 1130 3620 1130 {lab=\\dstage[2].id.d0\\}
N 3620 1130 3620 2630 {lab=\\dstage[2].id.d0\\}
N 3620 2630 3710 2630 {lab=\\dstage[2].id.d0\\}
C {devices/lab_wire.sym} 3540 2270 0 0 {lab=\\dstage[2].id.d0\\}
N 4040 2450 4120 2450 {lab=\\dstage[2].id.d2\\}
N 4120 2450 4120 2130 {lab=\\dstage[2].id.d2\\}
N 4120 2130 4210 2130 {lab=\\dstage[2].id.d2\\}
C {devices/lab_wire.sym} 4040 2450 0 0 {lab=\\dstage[2].id.d2\\}
N 250 1810 2230 1810 {lab=trim[2]}
N 2230 1810 2230 2170 {lab=trim[2]}
N 2230 2170 4210 2170 {lab=trim[2]}
C {devices/lab_wire.sym} 250 1810 0 0 {lab=trim[2]}
N 4290 2130 4380 2130 {lab=\\dstage[2].id.out\\}
N 4380 2130 4380 2200 {lab=\\dstage[2].id.out\\}
N 4380 2200 4460 2200 {lab=\\dstage[2].id.out\\}
C {devices/lab_wire.sym} 4290 2130 0 0 {lab=\\dstage[2].id.out\\}
N 3540 2270 3440 2270 {lab=\\dstage[2].id.out\\}
N 3440 2270 3440 1110 {lab=\\dstage[2].id.out\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.out\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.out\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.out\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.out\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.out\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.out\\}
N 3560 1130 4000 1130 {lab=\\dstage[2].id.out\\}
N 4000 1130 4000 2200 {lab=\\dstage[2].id.out\\}
N 4000 2200 4460 2200 {lab=\\dstage[2].id.out\\}
C {devices/lab_wire.sym} 3540 2270 0 0 {lab=\\dstage[2].id.out\\}
N 250 2980 1980 2980 {lab=trim[15]}
N 1980 2980 1980 2670 {lab=trim[15]}
N 1980 2670 3710 2670 {lab=trim[15]}
C {devices/lab_wire.sym} 250 2980 0 0 {lab=trim[15]}
N 3790 2630 3880 2630 {lab=\\dstage[2].id.d1\\}
N 3880 2630 3880 2450 {lab=\\dstage[2].id.d1\\}
N 3880 2450 3960 2450 {lab=\\dstage[2].id.d1\\}
C {devices/lab_wire.sym} 3790 2630 0 0 {lab=\\dstage[2].id.d1\\}
N 3540 2270 3440 2270 {lab=\\dstage[2].id.d1\\}
N 3440 2270 3440 1110 {lab=\\dstage[2].id.d1\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d1\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d1\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.d1\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d1\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d1\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d1\\}
N 3560 1130 3750 1130 {lab=\\dstage[2].id.d1\\}
N 3750 1130 3750 2450 {lab=\\dstage[2].id.d1\\}
N 3750 2450 3960 2450 {lab=\\dstage[2].id.d1\\}
C {devices/lab_wire.sym} 3540 2270 0 0 {lab=\\dstage[2].id.d1\\}
N 4540 2200 4710 2200 {lab=\\dstage[3].id.ts\\}
C {devices/lab_wire.sym} 4540 2200 0 0 {lab=\\dstage[3].id.ts\\}
N 4540 2200 4710 2200 {lab=\\dstage[3].id.ts\\}
C {devices/lab_wire.sym} 4540 2200 0 0 {lab=\\dstage[3].id.ts\\}
N 4540 2200 4710 2200 {lab=\\dstage[3].id.ts\\}
C {devices/lab_wire.sym} 4540 2200 0 0 {lab=\\dstage[3].id.ts\\}
N 4790 2200 4690 2200 {lab=\\dstage[3].id.d0\\}
N 4690 2200 4690 1430 {lab=\\dstage[3].id.d0\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d0\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d0\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.d0\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d0\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d0\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d0\\}
N 4810 1450 4880 1450 {lab=\\dstage[3].id.d0\\}
N 4880 1450 4880 2730 {lab=\\dstage[3].id.d0\\}
N 4880 2730 4960 2730 {lab=\\dstage[3].id.d0\\}
C {devices/lab_wire.sym} 4790 2200 0 0 {lab=\\dstage[3].id.d0\\}
N 5290 2470 5380 2470 {lab=\\dstage[3].id.d2\\}
N 5380 2470 5380 2270 {lab=\\dstage[3].id.d2\\}
N 5380 2270 5460 2270 {lab=\\dstage[3].id.d2\\}
C {devices/lab_wire.sym} 5290 2470 0 0 {lab=\\dstage[3].id.d2\\}
N 250 2080 2860 2080 {lab=trim[3]}
N 2860 2080 2860 2310 {lab=trim[3]}
N 2860 2310 5460 2310 {lab=trim[3]}
C {devices/lab_wire.sym} 250 2080 0 0 {lab=trim[3]}
N 5540 2270 5620 2270 {lab=\\dstage[3].id.out\\}
N 5620 2270 5620 2240 {lab=\\dstage[3].id.out\\}
N 5620 2240 5710 2240 {lab=\\dstage[3].id.out\\}
C {devices/lab_wire.sym} 5540 2270 0 0 {lab=\\dstage[3].id.out\\}
N 4790 2200 4690 2200 {lab=\\dstage[3].id.out\\}
N 4690 2200 4690 1430 {lab=\\dstage[3].id.out\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.out\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.out\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.out\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.out\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.out\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.out\\}
N 4810 1450 5250 1450 {lab=\\dstage[3].id.out\\}
N 5250 1450 5250 2240 {lab=\\dstage[3].id.out\\}
N 5250 2240 5710 2240 {lab=\\dstage[3].id.out\\}
C {devices/lab_wire.sym} 4790 2200 0 0 {lab=\\dstage[3].id.out\\}
N 250 3260 2600 3260 {lab=trim[16]}
N 2600 3260 2600 2770 {lab=trim[16]}
N 2600 2770 4960 2770 {lab=trim[16]}
C {devices/lab_wire.sym} 250 3260 0 0 {lab=trim[16]}
N 5040 2730 5120 2730 {lab=\\dstage[3].id.d1\\}
N 5120 2730 5120 2470 {lab=\\dstage[3].id.d1\\}
N 5120 2470 5210 2470 {lab=\\dstage[3].id.d1\\}
C {devices/lab_wire.sym} 5040 2730 0 0 {lab=\\dstage[3].id.d1\\}
N 4790 2200 4690 2200 {lab=\\dstage[3].id.d1\\}
N 4690 2200 4690 1430 {lab=\\dstage[3].id.d1\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d1\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d1\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.d1\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d1\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d1\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d1\\}
N 4810 1450 5000 1450 {lab=\\dstage[3].id.d1\\}
N 5000 1450 5000 2470 {lab=\\dstage[3].id.d1\\}
N 5000 2470 5210 2470 {lab=\\dstage[3].id.d1\\}
C {devices/lab_wire.sym} 4790 2200 0 0 {lab=\\dstage[3].id.d1\\}
N 5790 2240 5960 2240 {lab=\\dstage[4].id.ts\\}
C {devices/lab_wire.sym} 5790 2240 0 0 {lab=\\dstage[4].id.ts\\}
N 5790 2240 5960 2240 {lab=\\dstage[4].id.ts\\}
C {devices/lab_wire.sym} 5790 2240 0 0 {lab=\\dstage[4].id.ts\\}
N 5790 2240 5960 2240 {lab=\\dstage[4].id.ts\\}
C {devices/lab_wire.sym} 5790 2240 0 0 {lab=\\dstage[4].id.ts\\}
N 6040 2240 5940 2240 {lab=\\dstage[4].id.d0\\}
N 5940 2240 5940 1720 {lab=\\dstage[4].id.d0\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d0\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d0\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.d0\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d0\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d0\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d0\\}
N 6060 1740 6120 1740 {lab=\\dstage[4].id.d0\\}
N 6120 1740 6120 2890 {lab=\\dstage[4].id.d0\\}
N 6120 2890 6210 2890 {lab=\\dstage[4].id.d0\\}
C {devices/lab_wire.sym} 6040 2240 0 0 {lab=\\dstage[4].id.d0\\}
N 6540 2560 6620 2560 {lab=\\dstage[4].id.d2\\}
N 6620 2560 6620 2460 {lab=\\dstage[4].id.d2\\}
N 6620 2460 6710 2460 {lab=\\dstage[4].id.d2\\}
C {devices/lab_wire.sym} 6540 2560 0 0 {lab=\\dstage[4].id.d2\\}
N 250 2350 3480 2350 {lab=trim[4]}
N 3480 2350 3480 2500 {lab=trim[4]}
N 3480 2500 6710 2500 {lab=trim[4]}
C {devices/lab_wire.sym} 250 2350 0 0 {lab=trim[4]}
N 6790 2460 6880 2460 {lab=\\dstage[4].id.out\\}
N 6880 2460 6880 2350 {lab=\\dstage[4].id.out\\}
N 6880 2350 6960 2350 {lab=\\dstage[4].id.out\\}
C {devices/lab_wire.sym} 6790 2460 0 0 {lab=\\dstage[4].id.out\\}
N 6040 2240 5940 2240 {lab=\\dstage[4].id.out\\}
N 5940 2240 5940 1720 {lab=\\dstage[4].id.out\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.out\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.out\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.out\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.out\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.out\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.out\\}
N 6060 1740 6500 1740 {lab=\\dstage[4].id.out\\}
N 6500 1740 6500 2350 {lab=\\dstage[4].id.out\\}
N 6500 2350 6960 2350 {lab=\\dstage[4].id.out\\}
C {devices/lab_wire.sym} 6040 2240 0 0 {lab=\\dstage[4].id.out\\}
N 250 3540 3230 3540 {lab=trim[17]}
N 3230 3540 3230 2930 {lab=trim[17]}
N 3230 2930 6210 2930 {lab=trim[17]}
C {devices/lab_wire.sym} 250 3540 0 0 {lab=trim[17]}
N 6290 2890 6380 2890 {lab=\\dstage[4].id.d1\\}
N 6380 2890 6380 2560 {lab=\\dstage[4].id.d1\\}
N 6380 2560 6460 2560 {lab=\\dstage[4].id.d1\\}
C {devices/lab_wire.sym} 6290 2890 0 0 {lab=\\dstage[4].id.d1\\}
N 6040 2240 5940 2240 {lab=\\dstage[4].id.d1\\}
N 5940 2240 5940 1720 {lab=\\dstage[4].id.d1\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d1\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d1\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.d1\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d1\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d1\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d1\\}
N 6060 1740 6250 1740 {lab=\\dstage[4].id.d1\\}
N 6250 1740 6250 2560 {lab=\\dstage[4].id.d1\\}
N 6250 2560 6460 2560 {lab=\\dstage[4].id.d1\\}
C {devices/lab_wire.sym} 6040 2240 0 0 {lab=\\dstage[4].id.d1\\}
N 7040 2350 7210 2350 {lab=\\dstage[5].id.ts\\}
C {devices/lab_wire.sym} 7040 2350 0 0 {lab=\\dstage[5].id.ts\\}
N 7040 2350 7210 2350 {lab=\\dstage[5].id.ts\\}
C {devices/lab_wire.sym} 7040 2350 0 0 {lab=\\dstage[5].id.ts\\}
N 7040 2350 7210 2350 {lab=\\dstage[5].id.ts\\}
C {devices/lab_wire.sym} 7040 2350 0 0 {lab=\\dstage[5].id.ts\\}
N 7290 2350 7190 2350 {lab=\\dstage[5].id.d0\\}
N 7190 2350 7190 2010 {lab=\\dstage[5].id.d0\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d0\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d0\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.d0\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d0\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d0\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d0\\}
N 7310 2030 7380 2030 {lab=\\dstage[5].id.d0\\}
N 7380 2030 7380 3080 {lab=\\dstage[5].id.d0\\}
N 7380 3080 7460 3080 {lab=\\dstage[5].id.d0\\}
C {devices/lab_wire.sym} 7290 2350 0 0 {lab=\\dstage[5].id.d0\\}
N 7790 2710 7880 2710 {lab=\\dstage[5].id.d2\\}
N 7880 2710 7880 2660 {lab=\\dstage[5].id.d2\\}
N 7880 2660 7960 2660 {lab=\\dstage[5].id.d2\\}
C {devices/lab_wire.sym} 7790 2710 0 0 {lab=\\dstage[5].id.d2\\}
N 250 2610 4100 2610 {lab=trim[5]}
N 4100 2610 4100 2700 {lab=trim[5]}
N 4100 2700 7960 2700 {lab=trim[5]}
C {devices/lab_wire.sym} 250 2610 0 0 {lab=trim[5]}
N 8040 2660 8160 2660 {lab=\\dstage[5].id.out\\}
N 8160 2660 8160 2300 {lab=\\dstage[5].id.out\\}
N 8160 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2500 {lab=\\dstage[5].id.out\\}
N 8310 2500 8210 2500 {lab=\\dstage[5].id.out\\}
C {devices/lab_wire.sym} 8040 2660 0 0 {lab=\\dstage[5].id.out\\}
N 8040 2660 8100 2660 {lab=\\dstage[5].id.out\\}
N 8100 2660 8100 2300 {lab=\\dstage[5].id.out\\}
N 8100 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2500 {lab=\\dstage[5].id.out\\}
N 8310 2500 8210 2500 {lab=\\dstage[5].id.out\\}
C {devices/lab_wire.sym} 8040 2660 0 0 {lab=\\dstage[5].id.out\\}
N 7290 2350 7190 2350 {lab=\\dstage[5].id.out\\}
N 7190 2350 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7780 2030 {lab=\\dstage[5].id.out\\}
N 7780 2030 7780 2300 {lab=\\dstage[5].id.out\\}
N 7780 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2500 {lab=\\dstage[5].id.out\\}
N 8310 2500 8210 2500 {lab=\\dstage[5].id.out\\}
C {devices/lab_wire.sym} 7290 2350 0 0 {lab=\\dstage[5].id.out\\}
N 7290 2350 7190 2350 {lab=\\dstage[5].id.out\\}
N 7190 2350 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7720 2030 {lab=\\dstage[5].id.out\\}
N 7720 2030 7720 2300 {lab=\\dstage[5].id.out\\}
N 7720 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2500 {lab=\\dstage[5].id.out\\}
N 8310 2500 8210 2500 {lab=\\dstage[5].id.out\\}
C {devices/lab_wire.sym} 7290 2350 0 0 {lab=\\dstage[5].id.out\\}
N 250 3800 3860 3800 {lab=trim[18]}
N 3860 3800 3860 3120 {lab=trim[18]}
N 3860 3120 7460 3120 {lab=trim[18]}
C {devices/lab_wire.sym} 250 3800 0 0 {lab=trim[18]}
N 7540 3080 7620 3080 {lab=\\dstage[5].id.d1\\}
N 7620 3080 7620 2710 {lab=\\dstage[5].id.d1\\}
N 7620 2710 7710 2710 {lab=\\dstage[5].id.d1\\}
C {devices/lab_wire.sym} 7540 3080 0 0 {lab=\\dstage[5].id.d1\\}
N 7290 2350 7190 2350 {lab=\\dstage[5].id.d1\\}
N 7190 2350 7190 2010 {lab=\\dstage[5].id.d1\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d1\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d1\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.d1\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d1\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d1\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d1\\}
N 7310 2030 7500 2030 {lab=\\dstage[5].id.d1\\}
N 7500 2030 7500 2710 {lab=\\dstage[5].id.d1\\}
N 7500 2710 7710 2710 {lab=\\dstage[5].id.d1\\}
C {devices/lab_wire.sym} 7290 2350 0 0 {lab=\\dstage[5].id.d1\\}
N 8290 2500 8460 2500 {lab=\\dstage[6].id.ts\\}
C {devices/lab_wire.sym} 8290 2500 0 0 {lab=\\dstage[6].id.ts\\}
N 8290 2500 8460 2500 {lab=\\dstage[6].id.ts\\}
C {devices/lab_wire.sym} 8290 2500 0 0 {lab=\\dstage[6].id.ts\\}
N 8290 2500 8460 2500 {lab=\\dstage[6].id.ts\\}
C {devices/lab_wire.sym} 8290 2500 0 0 {lab=\\dstage[6].id.ts\\}
N 8540 2500 8440 2500 {lab=\\dstage[6].id.d0\\}
N 8440 2500 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d0\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d0\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8620 2300 {lab=\\dstage[6].id.d0\\}
N 8620 2300 8620 3280 {lab=\\dstage[6].id.d0\\}
N 8620 3280 8710 3280 {lab=\\dstage[6].id.d0\\}
C {devices/lab_wire.sym} 8540 2500 0 0 {lab=\\dstage[6].id.d0\\}
N 9040 2890 9120 2890 {lab=\\dstage[6].id.d2\\}
N 9120 2890 9120 2880 {lab=\\dstage[6].id.d2\\}
N 9120 2880 9210 2880 {lab=\\dstage[6].id.d2\\}
C {devices/lab_wire.sym} 9040 2890 0 0 {lab=\\dstage[6].id.d2\\}
N 250 2870 4730 2870 {lab=trim[6]}
N 4730 2870 4730 2920 {lab=trim[6]}
N 4730 2920 9210 2920 {lab=trim[6]}
C {devices/lab_wire.sym} 250 2870 0 0 {lab=trim[6]}
N 9290 2880 9380 2880 {lab=\\dstage[6].id.out\\}
N 9380 2880 9380 2690 {lab=\\dstage[6].id.out\\}
N 9380 2690 9460 2690 {lab=\\dstage[6].id.out\\}
C {devices/lab_wire.sym} 9290 2880 0 0 {lab=\\dstage[6].id.out\\}
N 8540 2500 8440 2500 {lab=\\dstage[6].id.out\\}
N 8440 2500 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.out\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.out\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8690 2300 {lab=\\dstage[6].id.out\\}
N 8690 2300 8690 2280 {lab=\\dstage[6].id.out\\}
N 8690 2280 8810 2280 {lab=\\dstage[6].id.out\\}
N 8810 2280 8810 2300 {lab=\\dstage[6].id.out\\}
N 8810 2300 8980 2300 {lab=\\dstage[6].id.out\\}
N 8980 2300 8980 2320 {lab=\\dstage[6].id.out\\}
N 8980 2320 9020 2320 {lab=\\dstage[6].id.out\\}
N 9020 2320 9020 2570 {lab=\\dstage[6].id.out\\}
N 9020 2570 9000 2690 {lab=\\dstage[6].id.out\\}
N 9000 2690 9460 2690 {lab=\\dstage[6].id.out\\}
C {devices/lab_wire.sym} 8540 2500 0 0 {lab=\\dstage[6].id.out\\}
N 250 4060 4480 4060 {lab=trim[19]}
N 4480 4060 4480 3320 {lab=trim[19]}
N 4480 3320 8710 3320 {lab=trim[19]}
C {devices/lab_wire.sym} 250 4060 0 0 {lab=trim[19]}
N 8790 3280 8880 3280 {lab=\\dstage[6].id.d1\\}
N 8880 3280 8880 2890 {lab=\\dstage[6].id.d1\\}
N 8880 2890 8960 2890 {lab=\\dstage[6].id.d1\\}
C {devices/lab_wire.sym} 8790 3280 0 0 {lab=\\dstage[6].id.d1\\}
N 8540 2500 8440 2500 {lab=\\dstage[6].id.d1\\}
N 8440 2500 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d1\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d1\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8690 2300 {lab=\\dstage[6].id.d1\\}
N 8690 2300 8690 2320 {lab=\\dstage[6].id.d1\\}
N 8690 2320 8810 2320 {lab=\\dstage[6].id.d1\\}
N 8810 2320 8810 3160 {lab=\\dstage[6].id.d1\\}
N 8810 3160 8750 2890 {lab=\\dstage[6].id.d1\\}
N 8750 2890 8960 2890 {lab=\\dstage[6].id.d1\\}
C {devices/lab_wire.sym} 8540 2500 0 0 {lab=\\dstage[6].id.d1\\}
N 9540 2690 9710 2690 {lab=\\dstage[7].id.ts\\}
C {devices/lab_wire.sym} 9540 2690 0 0 {lab=\\dstage[7].id.ts\\}
N 9540 2690 9710 2690 {lab=\\dstage[7].id.ts\\}
C {devices/lab_wire.sym} 9540 2690 0 0 {lab=\\dstage[7].id.ts\\}
N 9540 2690 9710 2690 {lab=\\dstage[7].id.ts\\}
C {devices/lab_wire.sym} 9540 2690 0 0 {lab=\\dstage[7].id.ts\\}
N 9790 2690 9690 2690 {lab=\\dstage[7].id.d0\\}
N 9690 2690 9690 2550 {lab=\\dstage[7].id.d0\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d0\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d0\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.d0\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d0\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d0\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d0\\}
N 9810 2570 9880 2570 {lab=\\dstage[7].id.d0\\}
N 9880 2570 9880 3510 {lab=\\dstage[7].id.d0\\}
N 9880 3510 9960 3510 {lab=\\dstage[7].id.d0\\}
C {devices/lab_wire.sym} 9790 2690 0 0 {lab=\\dstage[7].id.d0\\}
N 10290 3100 10380 3100 {lab=\\dstage[7].id.d2\\}
N 10380 3100 10380 3110 {lab=\\dstage[7].id.d2\\}
N 10380 3110 10460 3110 {lab=\\dstage[7].id.d2\\}
C {devices/lab_wire.sym} 10290 3100 0 0 {lab=\\dstage[7].id.d2\\}
N 250 3130 5360 3130 {lab=trim[7]}
N 5360 3130 5360 3150 {lab=trim[7]}
N 5360 3150 10460 3150 {lab=trim[7]}
C {devices/lab_wire.sym} 250 3130 0 0 {lab=trim[7]}
N 10540 3110 10620 3110 {lab=\\dstage[7].id.out\\}
N 10620 3110 10620 2900 {lab=\\dstage[7].id.out\\}
N 10620 2900 10710 2900 {lab=\\dstage[7].id.out\\}
C {devices/lab_wire.sym} 10540 3110 0 0 {lab=\\dstage[7].id.out\\}
N 9790 2690 9690 2690 {lab=\\dstage[7].id.out\\}
N 9690 2690 9690 2550 {lab=\\dstage[7].id.out\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.out\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.out\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.out\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.out\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.out\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.out\\}
N 9810 2570 10250 2570 {lab=\\dstage[7].id.out\\}
N 10250 2570 10250 2900 {lab=\\dstage[7].id.out\\}
N 10250 2900 10710 2900 {lab=\\dstage[7].id.out\\}
C {devices/lab_wire.sym} 9790 2690 0 0 {lab=\\dstage[7].id.out\\}
N 250 4320 5100 4320 {lab=trim[20]}
N 5100 4320 5100 3550 {lab=trim[20]}
N 5100 3550 9960 3550 {lab=trim[20]}
C {devices/lab_wire.sym} 250 4320 0 0 {lab=trim[20]}
N 10040 3510 10120 3510 {lab=\\dstage[7].id.d1\\}
N 10120 3510 10120 3100 {lab=\\dstage[7].id.d1\\}
N 10120 3100 10210 3100 {lab=\\dstage[7].id.d1\\}
C {devices/lab_wire.sym} 10040 3510 0 0 {lab=\\dstage[7].id.d1\\}
N 9790 2690 9690 2690 {lab=\\dstage[7].id.d1\\}
N 9690 2690 9690 2550 {lab=\\dstage[7].id.d1\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d1\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d1\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.d1\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d1\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d1\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d1\\}
N 9810 2570 10000 2570 {lab=\\dstage[7].id.d1\\}
N 10000 2570 10000 3100 {lab=\\dstage[7].id.d1\\}
N 10000 3100 10210 3100 {lab=\\dstage[7].id.d1\\}
C {devices/lab_wire.sym} 9790 2690 0 0 {lab=\\dstage[7].id.d1\\}
N 10790 2900 10960 2900 {lab=\\dstage[8].id.ts\\}
C {devices/lab_wire.sym} 10790 2900 0 0 {lab=\\dstage[8].id.ts\\}
N 10790 2900 10960 2900 {lab=\\dstage[8].id.ts\\}
C {devices/lab_wire.sym} 10790 2900 0 0 {lab=\\dstage[8].id.ts\\}
N 10790 2900 10960 2900 {lab=\\dstage[8].id.ts\\}
C {devices/lab_wire.sym} 10790 2900 0 0 {lab=\\dstage[8].id.ts\\}
N 11040 2900 10940 2900 {lab=\\dstage[8].id.d0\\}
N 10940 2900 10940 2810 {lab=\\dstage[8].id.d0\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d0\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d0\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.d0\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d0\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d0\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d0\\}
N 11060 2830 11120 2830 {lab=\\dstage[8].id.d0\\}
N 11120 2830 11120 3740 {lab=\\dstage[8].id.d0\\}
N 11120 3740 11210 3740 {lab=\\dstage[8].id.d0\\}
C {devices/lab_wire.sym} 11040 2900 0 0 {lab=\\dstage[8].id.d0\\}
N 11540 3320 11620 3320 {lab=\\dstage[8].id.d2\\}
N 11620 3320 11620 3350 {lab=\\dstage[8].id.d2\\}
N 11620 3350 11710 3350 {lab=\\dstage[8].id.d2\\}
C {devices/lab_wire.sym} 11540 3320 0 0 {lab=\\dstage[8].id.d2\\}
N 250 3380 5980 3380 {lab=trim[8]}
N 5980 3380 5980 3390 {lab=trim[8]}
N 5980 3390 11710 3390 {lab=trim[8]}
C {devices/lab_wire.sym} 250 3380 0 0 {lab=trim[8]}
N 11790 3350 11880 3350 {lab=\\dstage[8].id.out\\}
N 11880 3350 11880 3130 {lab=\\dstage[8].id.out\\}
N 11880 3130 11960 3130 {lab=\\dstage[8].id.out\\}
C {devices/lab_wire.sym} 11790 3350 0 0 {lab=\\dstage[8].id.out\\}
N 11040 2900 10940 2900 {lab=\\dstage[8].id.out\\}
N 10940 2900 10940 2810 {lab=\\dstage[8].id.out\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.out\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.out\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.out\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.out\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.out\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.out\\}
N 11060 2830 11500 2830 {lab=\\dstage[8].id.out\\}
N 11500 2830 11500 3130 {lab=\\dstage[8].id.out\\}
N 11500 3130 11960 3130 {lab=\\dstage[8].id.out\\}
C {devices/lab_wire.sym} 11040 2900 0 0 {lab=\\dstage[8].id.out\\}
N 250 4580 5730 4580 {lab=trim[21]}
N 5730 4580 5730 3780 {lab=trim[21]}
N 5730 3780 11210 3780 {lab=trim[21]}
C {devices/lab_wire.sym} 250 4580 0 0 {lab=trim[21]}
N 11290 3740 11380 3740 {lab=\\dstage[8].id.d1\\}
N 11380 3740 11380 3320 {lab=\\dstage[8].id.d1\\}
N 11380 3320 11460 3320 {lab=\\dstage[8].id.d1\\}
C {devices/lab_wire.sym} 11290 3740 0 0 {lab=\\dstage[8].id.d1\\}
N 11040 2900 10940 2900 {lab=\\dstage[8].id.d1\\}
N 10940 2900 10940 2810 {lab=\\dstage[8].id.d1\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d1\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d1\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.d1\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d1\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d1\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d1\\}
N 11060 2830 11250 2830 {lab=\\dstage[8].id.d1\\}
N 11250 2830 11250 3320 {lab=\\dstage[8].id.d1\\}
N 11250 3320 11460 3320 {lab=\\dstage[8].id.d1\\}
C {devices/lab_wire.sym} 11040 2900 0 0 {lab=\\dstage[8].id.d1\\}
N 12040 3130 12210 3130 {lab=\\dstage[9].id.ts\\}
C {devices/lab_wire.sym} 12040 3130 0 0 {lab=\\dstage[9].id.ts\\}
N 12040 3130 12210 3130 {lab=\\dstage[9].id.ts\\}
C {devices/lab_wire.sym} 12040 3130 0 0 {lab=\\dstage[9].id.ts\\}
N 12040 3130 12210 3130 {lab=\\dstage[9].id.ts\\}
C {devices/lab_wire.sym} 12040 3130 0 0 {lab=\\dstage[9].id.ts\\}
N 12290 3130 12190 3130 {lab=\\dstage[9].id.d0\\}
N 12190 3130 12190 3060 {lab=\\dstage[9].id.d0\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d0\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d0\\}
N 12310 3080 12190 3080 {lab=\\dstage[9].id.d0\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d0\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d0\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d0\\}
N 12310 3080 12380 3080 {lab=\\dstage[9].id.d0\\}
N 12380 3080 12380 3980 {lab=\\dstage[9].id.d0\\}
N 12380 3980 12460 3980 {lab=\\dstage[9].id.d0\\}
C {devices/lab_wire.sym} 12290 3130 0 0 {lab=\\dstage[9].id.d0\\}
N 12790 3550 12880 3550 {lab=\\dstage[9].id.d2\\}
N 12880 3550 12880 3590 {lab=\\dstage[9].id.d2\\}
N 12880 3590 12960 3590 {lab=\\dstage[9].id.d2\\}
C {devices/lab_wire.sym} 12790 3550 0 0 {lab=\\dstage[9].id.d2\\}
N 250 3630 6600 3630 {lab=trim[9]}
N 6600 3630 6600 3630 {lab=trim[9]}
N 6600 3630 12960 3630 {lab=trim[9]}
C {devices/lab_wire.sym} 250 3630 0 0 {lab=trim[9]}
N 250 4830 6360 4830 {lab=trim[22]}
N 6360 4830 6360 4020 {lab=trim[22]}
N 6360 4020 12460 4020 {lab=trim[22]}
C {devices/lab_wire.sym} 250 4830 0 0 {lab=trim[22]}
N 12540 3980 12620 3980 {lab=\\dstage[9].id.d1\\}
N 12620 3980 12620 3550 {lab=\\dstage[9].id.d1\\}
N 12620 3550 12710 3550 {lab=\\dstage[9].id.d1\\}
C {devices/lab_wire.sym} 12540 3980 0 0 {lab=\\dstage[9].id.d1\\}
N 12290 3130 12190 3130 {lab=\\dstage[9].id.d1\\}
N 12190 3130 12190 3060 {lab=\\dstage[9].id.d1\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d1\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d1\\}
N 12310 3080 12190 3080 {lab=\\dstage[9].id.d1\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d1\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d1\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d1\\}
N 12310 3080 12500 3080 {lab=\\dstage[9].id.d1\\}
N 12500 3080 12500 3550 {lab=\\dstage[9].id.d1\\}
N 12500 3550 12710 3550 {lab=\\dstage[9].id.d1\\}
C {devices/lab_wire.sym} 12290 3130 0 0 {lab=\\dstage[9].id.d1\\}
N 16790 3060 16960 3060 {lab=c[0]}
C {devices/lab_wire.sym} 16790 3060 0 0 {lab=c[0]}
N 8290 2500 8460 2500 {lab=c[1]}
C {devices/lab_wire.sym} 8290 2500 0 0 {lab=c[1]}
N 280 500 370 500 {lab=\\iss.one\\}
N 370 500 370 1430 {lab=\\iss.one\\}
N 370 1430 460 1430 {lab=\\iss.one\\}
C {devices/lab_wire.sym} 280 500 0 0 {lab=\\iss.one\\}
N 250 2360 340 2360 {lab=reset}
N 340 2360 340 3040 {lab=reset}
N 340 3040 440 3040 {lab=reset}
C {devices/lab_wire.sym} 250 2360 0 0 {lab=reset}
N 250 2360 360 2360 {lab=reset}
N 360 2360 360 1470 {lab=reset}
N 360 1470 460 1470 {lab=reset}
C {devices/lab_wire.sym} 250 2360 0 0 {lab=reset}
N 250 3760 340 3760 {lab=trim[12]}
N 340 3760 340 3080 {lab=trim[12]}
N 340 3080 440 3080 {lab=trim[12]}
C {devices/lab_wire.sym} 250 3760 0 0 {lab=trim[12]}
N 250 3760 8360 3760 {lab=trim[12]}
N 8360 3760 8360 3950 {lab=trim[12]}
N 8360 3950 16460 3950 {lab=trim[12]}
C {devices/lab_wire.sym} 250 3760 0 0 {lab=trim[12]}
N 15790 3840 15690 3840 {lab=\\iss.d0\\}
N 15690 3840 15690 2150 {lab=\\iss.d0\\}
N 15690 2150 15810 2150 {lab=\\iss.d0\\}
N 15810 2150 15810 2170 {lab=\\iss.d0\\}
N 15810 2170 15880 2170 {lab=\\iss.d0\\}
N 15880 2170 15880 4300 {lab=\\iss.d0\\}
N 15880 4300 15960 4300 {lab=\\iss.d0\\}
C {devices/lab_wire.sym} 15790 3840 0 0 {lab=\\iss.d0\\}
N 16290 4070 16380 4070 {lab=\\iss.d2\\}
N 16380 4070 16380 3910 {lab=\\iss.d2\\}
N 16380 3910 16460 3910 {lab=\\iss.d2\\}
C {devices/lab_wire.sym} 16290 4070 0 0 {lab=\\iss.d2\\}
N 250 4750 8100 4750 {lab=trim[25]}
N 8100 4750 8100 4340 {lab=trim[25]}
N 8100 4340 15960 4340 {lab=trim[25]}
C {devices/lab_wire.sym} 250 4750 0 0 {lab=trim[25]}
N 16040 4300 16120 4300 {lab=\\iss.d1\\}
N 16120 4300 16120 4070 {lab=\\iss.d1\\}
N 16120 4070 16210 4070 {lab=\\iss.d1\\}
C {devices/lab_wire.sym} 16040 4300 0 0 {lab=\\iss.d1\\}
N 15790 3840 15690 3840 {lab=\\iss.d1\\}
N 15690 3840 15690 2150 {lab=\\iss.d1\\}
N 15690 2150 15810 2150 {lab=\\iss.d1\\}
N 15810 2150 15810 2170 {lab=\\iss.d1\\}
N 15810 2170 16000 2170 {lab=\\iss.d1\\}
N 16000 2170 16000 4070 {lab=\\iss.d1\\}
N 16000 4070 16210 4070 {lab=\\iss.d1\\}
C {devices/lab_wire.sym} 15790 3840 0 0 {lab=\\iss.d1\\}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 17250 3060 0 0 {name=X_1_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 8750 2500 0 0 {name=X_2_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 750 3000 0 0 {name=X\\dstage[0].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 1000 3000 0 0 {name=X\\dstage[0].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1750 2020 0 0 {name=X\\dstage[0].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1250 2680 0 0 {name=X\\dstage[0].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 1000 3000 0 0 {name=X\\dstage[0].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 1000 3000 0 0 {name=X\\dstage[0].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 1500 2840 0 0 {name=X\\dstage[0].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 13250 3360 0 0 {name=X\\dstage[10].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 13500 3360 0 0 {name=X\\dstage[10].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 14250 3840 0 0 {name=X\\dstage[10].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13750 4220 0 0 {name=X\\dstage[10].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 13500 3360 0 0 {name=X\\dstage[10].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 13500 3360 0 0 {name=X\\dstage[10].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 14000 3790 0 0 {name=X\\dstage[10].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 14500 3600 0 0 {name=X\\dstage[11].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 14750 3600 0 0 {name=X\\dstage[11].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15500 4090 0 0 {name=X\\dstage[11].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15000 4470 0 0 {name=X\\dstage[11].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 250 3590 0 0 {name=X\\dstage[11].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 14750 3600 0 0 {name=X\\dstage[11].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 15250 4030 0 0 {name=X\\dstage[11].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 2000 2510 0 0 {name=X\\dstage[1].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 2250 2510 0 0 {name=X\\dstage[1].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3000 2030 0 0 {name=X\\dstage[1].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 2500 2590 0 0 {name=X\\dstage[1].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 2250 2510 0 0 {name=X\\dstage[1].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 2250 2510 0 0 {name=X\\dstage[1].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 2750 2550 0 0 {name=X\\dstage[1].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 3250 2270 0 0 {name=X\\dstage[2].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 3500 2270 0 0 {name=X\\dstage[2].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 4250 2130 0 0 {name=X\\dstage[2].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3750 2630 0 0 {name=X\\dstage[2].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 3500 2270 0 0 {name=X\\dstage[2].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 3500 2270 0 0 {name=X\\dstage[2].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 4000 2450 0 0 {name=X\\dstage[2].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 4500 2200 0 0 {name=X\\dstage[3].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 4750 2200 0 0 {name=X\\dstage[3].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5500 2270 0 0 {name=X\\dstage[3].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5000 2730 0 0 {name=X\\dstage[3].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 4750 2200 0 0 {name=X\\dstage[3].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 4750 2200 0 0 {name=X\\dstage[3].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 5250 2470 0 0 {name=X\\dstage[3].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 5750 2240 0 0 {name=X\\dstage[4].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 6000 2240 0 0 {name=X\\dstage[4].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6750 2460 0 0 {name=X\\dstage[4].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6250 2890 0 0 {name=X\\dstage[4].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 6000 2240 0 0 {name=X\\dstage[4].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 6000 2240 0 0 {name=X\\dstage[4].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 6500 2560 0 0 {name=X\\dstage[4].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 7000 2350 0 0 {name=X\\dstage[5].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 7250 2350 0 0 {name=X\\dstage[5].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8000 2660 0 0 {name=X\\dstage[5].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 7500 3080 0 0 {name=X\\dstage[5].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 7250 2350 0 0 {name=X\\dstage[5].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 7250 2350 0 0 {name=X\\dstage[5].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 7750 2710 0 0 {name=X\\dstage[5].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 8250 2500 0 0 {name=X\\dstage[6].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 8500 2500 0 0 {name=X\\dstage[6].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 9250 2880 0 0 {name=X\\dstage[6].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8750 3280 0 0 {name=X\\dstage[6].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 8500 2500 0 0 {name=X\\dstage[6].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 8500 2500 0 0 {name=X\\dstage[6].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 9000 2890 0 0 {name=X\\dstage[6].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 9500 2690 0 0 {name=X\\dstage[7].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 9750 2690 0 0 {name=X\\dstage[7].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10500 3110 0 0 {name=X\\dstage[7].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10000 3510 0 0 {name=X\\dstage[7].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 9750 2690 0 0 {name=X\\dstage[7].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 9750 2690 0 0 {name=X\\dstage[7].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 10250 3100 0 0 {name=X\\dstage[7].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 10750 2900 0 0 {name=X\\dstage[8].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 11000 2900 0 0 {name=X\\dstage[8].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11750 3350 0 0 {name=X\\dstage[8].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11250 3740 0 0 {name=X\\dstage[8].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 11000 2900 0 0 {name=X\\dstage[8].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 11000 2900 0 0 {name=X\\dstage[8].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 11500 3320 0 0 {name=X\\dstage[8].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 12000 3130 0 0 {name=X\\dstage[9].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 12250 3130 0 0 {name=X\\dstage[9].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13000 3590 0 0 {name=X\\dstage[9].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 12500 3980 0 0 {name=X\\dstage[9].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 12250 3130 0 0 {name=X\\dstage[9].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 12250 3130 0 0 {name=X\\dstage[9].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 12750 3550 0 0 {name=X\\dstage[9].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 16750 3060 0 0 {name=Xibufp00 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 17000 3060 0 0 {name=Xibufp01 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 8250 2500 0 0 {name=Xibufp10 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 8500 2500 0 0 {name=Xibufp11 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__conb_1.sym} 250 500 0 0 {name=X\\iss.const1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__or2_2.sym} 500 3060 0 0 {name=X\\iss.ctrlen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 15750 3840 0 0 {name=X\\iss.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16500 3910 0 0 {name=X\\iss.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16000 4300 0 0 {name=X\\iss.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 500 3840 0 0 {name=X\\iss.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 15750 3840 0 0 {name=X\\iss.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 16250 4070 0 0 {name=X\\iss.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_1.sym} 500 1430 0 0 {name=X\\iss.reseten0 VCCPIN=vcc VSSPIN=gnd}
C {devices/opin.sym} 17500 3060 0 0 {lab=clockp[0]}
C {devices/opin.sym} 9000 2500 0 0 {lab=clockp[1]}
C {devices/ipin.sym} 250 2360 0 0 {lab=reset}
C {devices/ipin.sym} 250 1210 0 0 {lab=trim[0]}
C {devices/ipin.sym} 250 1520 0 0 {lab=trim[1]}
C {devices/ipin.sym} 250 1810 0 0 {lab=trim[2]}
C {devices/ipin.sym} 250 2080 0 0 {lab=trim[3]}
C {devices/ipin.sym} 250 2350 0 0 {lab=trim[4]}
C {devices/ipin.sym} 250 2610 0 0 {lab=trim[5]}
C {devices/ipin.sym} 250 2870 0 0 {lab=trim[6]}
C {devices/ipin.sym} 250 3130 0 0 {lab=trim[7]}
C {devices/ipin.sym} 250 3380 0 0 {lab=trim[8]}
C {devices/ipin.sym} 250 3630 0 0 {lab=trim[9]}
C {devices/ipin.sym} 250 3890 0 0 {lab=trim[10]}
C {devices/ipin.sym} 250 4140 0 0 {lab=trim[11]}
C {devices/ipin.sym} 250 3760 0 0 {lab=trim[12]}
C {devices/ipin.sym} 250 2350 0 0 {lab=trim[13]}
C {devices/ipin.sym} 250 2680 0 0 {lab=trim[14]}
C {devices/ipin.sym} 250 2980 0 0 {lab=trim[15]}
C {devices/ipin.sym} 250 3260 0 0 {lab=trim[16]}
C {devices/ipin.sym} 250 3540 0 0 {lab=trim[17]}
C {devices/ipin.sym} 250 3800 0 0 {lab=trim[18]}
C {devices/ipin.sym} 250 4060 0 0 {lab=trim[19]}
C {devices/ipin.sym} 250 4320 0 0 {lab=trim[20]}
C {devices/ipin.sym} 250 4580 0 0 {lab=trim[21]}
C {devices/ipin.sym} 250 4830 0 0 {lab=trim[22]}
C {devices/ipin.sym} 250 5080 0 0 {lab=trim[23]}
C {devices/ipin.sym} 250 5340 0 0 {lab=trim[24]}
C {devices/ipin.sym} 250 4750 0 0 {lab=trim[25]}
