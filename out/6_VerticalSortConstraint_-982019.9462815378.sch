v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
N 22040 3920 22210 3920 {lab=_0_[0]}
N 22290 3920 22500 3920 {lab=clockp[0]}
N 11040 3200 11210 3200 {lab=_0_[1]}
N 11290 3200 11500 3200 {lab=clockp[1]}
N 21540 5030 11100 5030 {lab=\\dstage[0].id.in\\}
N 11100 5030 11100 380 {lab=\\dstage[0].id.in\\}
N 11100 380 940 380 {lab=\\dstage[0].id.in\\}
N 940 380 940 360 {lab=\\dstage[0].id.in\\}
N 940 360 1060 360 {lab=\\dstage[0].id.in\\}
N 1060 360 1060 3810 {lab=\\dstage[0].id.in\\}
N 1060 3810 710 3810 {lab=\\dstage[0].id.in\\}
N 540 5050 640 5050 {lab=\\dstage[0].id.in\\}
N 640 5050 640 3810 {lab=\\dstage[0].id.in\\}
N 640 3810 710 3810 {lab=\\dstage[0].id.in\\}
N 540 1680 620 1680 {lab=\\dstage[0].id.in\\}
N 620 1680 620 3810 {lab=\\dstage[0].id.in\\}
N 620 3810 710 3810 {lab=\\dstage[0].id.in\\}
N 21540 5030 21620 5030 {lab=\\dstage[0].id.in\\}
N 21620 5030 21620 3920 {lab=\\dstage[0].id.in\\}
N 21620 3920 21710 3920 {lab=\\dstage[0].id.in\\}
N 540 5050 11120 5050 {lab=\\dstage[0].id.in\\}
N 11120 5050 11120 3920 {lab=\\dstage[0].id.in\\}
N 11120 3920 21710 3920 {lab=\\dstage[0].id.in\\}
N 540 1680 11140 1680 {lab=\\dstage[0].id.in\\}
N 11140 1680 11140 3920 {lab=\\dstage[0].id.in\\}
N 11140 3920 21710 3920 {lab=\\dstage[0].id.in\\}
N 790 3810 960 3810 {lab=\\dstage[0].id.ts\\}
N 790 3810 960 3810 {lab=\\dstage[0].id.ts\\}
N 790 3810 960 3810 {lab=\\dstage[0].id.ts\\}
N 1040 3810 940 3810 {lab=\\dstage[0].id.d0\\}
N 940 3810 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d0\\}
N 940 380 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 1120 380 {lab=\\dstage[0].id.d0\\}
N 1120 380 1120 3330 {lab=\\dstage[0].id.d0\\}
N 1120 3330 1210 3330 {lab=\\dstage[0].id.d0\\}
N 1540 3570 1620 3570 {lab=\\dstage[0].id.d2\\}
N 1620 3570 1620 2450 {lab=\\dstage[0].id.d2\\}
N 1620 2450 1710 2450 {lab=\\dstage[0].id.d2\\}
N 250 1340 980 1340 {lab=trim[0]}
N 980 1340 980 2490 {lab=trim[0]}
N 980 2490 1710 2490 {lab=trim[0]}
N 250 1340 500 1340 {lab=trim[0]}
N 1790 2450 1880 2450 {lab=\\dstage[0].id.out\\}
N 1880 2450 1880 3130 {lab=\\dstage[0].id.out\\}
N 1880 3130 1960 3130 {lab=\\dstage[0].id.out\\}
N 1040 3810 940 3810 {lab=\\dstage[0].id.out\\}
N 940 3810 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 940 380 {lab=\\dstage[0].id.out\\}
N 940 380 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 1500 380 {lab=\\dstage[0].id.out\\}
N 1500 380 1500 3130 {lab=\\dstage[0].id.out\\}
N 1500 3130 1960 3130 {lab=\\dstage[0].id.out\\}
N 250 2850 730 2850 {lab=trim[17]}
N 730 2850 730 3370 {lab=trim[17]}
N 730 3370 1210 3370 {lab=trim[17]}
N 250 2850 500 2850 {lab=trim[17]}
N 1290 3330 1380 3330 {lab=\\dstage[0].id.d1\\}
N 1380 3330 1380 3570 {lab=\\dstage[0].id.d1\\}
N 1380 3570 1460 3570 {lab=\\dstage[0].id.d1\\}
N 1040 3810 940 3810 {lab=\\dstage[0].id.d1\\}
N 940 3810 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d1\\}
N 940 380 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 1250 380 {lab=\\dstage[0].id.d1\\}
N 1250 380 1250 3570 {lab=\\dstage[0].id.d1\\}
N 1250 3570 1460 3570 {lab=\\dstage[0].id.d1\\}
N 13040 3870 13120 3870 {lab=\\dstage[10].id.in\\}
N 13120 3870 13120 3640 {lab=\\dstage[10].id.in\\}
N 13120 3640 13210 3640 {lab=\\dstage[10].id.in\\}
N 12290 3410 12190 3410 {lab=\\dstage[10].id.in\\}
N 12190 3410 12190 3260 {lab=\\dstage[10].id.in\\}
N 12190 3260 12310 3260 {lab=\\dstage[10].id.in\\}
N 12310 3260 12310 3280 {lab=\\dstage[10].id.in\\}
N 12310 3280 12190 3280 {lab=\\dstage[10].id.in\\}
N 12190 3280 12190 3260 {lab=\\dstage[10].id.in\\}
N 12190 3260 12310 3260 {lab=\\dstage[10].id.in\\}
N 12310 3260 12310 3280 {lab=\\dstage[10].id.in\\}
N 12310 3280 12750 3280 {lab=\\dstage[10].id.in\\}
N 12750 3280 12750 3640 {lab=\\dstage[10].id.in\\}
N 12750 3640 13210 3640 {lab=\\dstage[10].id.in\\}
N 13290 3640 13460 3640 {lab=\\dstage[10].id.ts\\}
N 13290 3640 13460 3640 {lab=\\dstage[10].id.ts\\}
N 13290 3640 13460 3640 {lab=\\dstage[10].id.ts\\}
N 13540 3640 13440 3640 {lab=\\dstage[10].id.d0\\}
N 13440 3640 13440 3510 {lab=\\dstage[10].id.d0\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.d0\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.d0\\}
N 13560 3530 13440 3530 {lab=\\dstage[10].id.d0\\}
N 13440 3530 13440 3510 {lab=\\dstage[10].id.d0\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.d0\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.d0\\}
N 13560 3530 13620 3530 {lab=\\dstage[10].id.d0\\}
N 13620 3530 13620 4660 {lab=\\dstage[10].id.d0\\}
N 13620 4660 13710 4660 {lab=\\dstage[10].id.d0\\}
N 14040 4150 14120 4150 {lab=\\dstage[10].id.d2\\}
N 14120 4150 14120 4120 {lab=\\dstage[10].id.d2\\}
N 14120 4120 14210 4120 {lab=\\dstage[10].id.d2\\}
N 250 4080 7230 4080 {lab=trim[10]}
N 7230 4080 7230 4160 {lab=trim[10]}
N 7230 4160 14210 4160 {lab=trim[10]}
N 250 4080 500 4080 {lab=trim[10]}
N 14290 4120 14380 4120 {lab=\\dstage[10].id.out\\}
N 14380 4120 14380 3880 {lab=\\dstage[10].id.out\\}
N 14380 3880 14460 3880 {lab=\\dstage[10].id.out\\}
N 13540 3640 13440 3640 {lab=\\dstage[10].id.out\\}
N 13440 3640 13440 3510 {lab=\\dstage[10].id.out\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.out\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.out\\}
N 13560 3530 13440 3530 {lab=\\dstage[10].id.out\\}
N 13440 3530 13440 3510 {lab=\\dstage[10].id.out\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.out\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.out\\}
N 13560 3530 14000 3530 {lab=\\dstage[10].id.out\\}
N 14000 3530 14000 3880 {lab=\\dstage[10].id.out\\}
N 14000 3880 14460 3880 {lab=\\dstage[10].id.out\\}
N 250 5680 6980 5680 {lab=trim[27]}
N 6980 5680 6980 4700 {lab=trim[27]}
N 6980 4700 13710 4700 {lab=trim[27]}
N 250 5680 500 5680 {lab=trim[27]}
N 13790 4660 13880 4660 {lab=\\dstage[10].id.d1\\}
N 13880 4660 13880 4150 {lab=\\dstage[10].id.d1\\}
N 13880 4150 13960 4150 {lab=\\dstage[10].id.d1\\}
N 13540 3640 13440 3640 {lab=\\dstage[10].id.d1\\}
N 13440 3640 13440 3510 {lab=\\dstage[10].id.d1\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.d1\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.d1\\}
N 13560 3530 13440 3530 {lab=\\dstage[10].id.d1\\}
N 13440 3530 13440 3510 {lab=\\dstage[10].id.d1\\}
N 13440 3510 13560 3510 {lab=\\dstage[10].id.d1\\}
N 13560 3510 13560 3530 {lab=\\dstage[10].id.d1\\}
N 13560 3530 13750 3530 {lab=\\dstage[10].id.d1\\}
N 13750 3530 13750 4150 {lab=\\dstage[10].id.d1\\}
N 13750 4150 13960 4150 {lab=\\dstage[10].id.d1\\}
N 14540 3880 14710 3880 {lab=\\dstage[11].id.ts\\}
N 14540 3880 14710 3880 {lab=\\dstage[11].id.ts\\}
N 14540 3880 14710 3880 {lab=\\dstage[11].id.ts\\}
N 14790 3880 14690 3880 {lab=\\dstage[11].id.d0\\}
N 14690 3880 14690 3770 {lab=\\dstage[11].id.d0\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.d0\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.d0\\}
N 14810 3790 14690 3790 {lab=\\dstage[11].id.d0\\}
N 14690 3790 14690 3770 {lab=\\dstage[11].id.d0\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.d0\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.d0\\}
N 14810 3790 14880 3790 {lab=\\dstage[11].id.d0\\}
N 14880 3790 14880 4910 {lab=\\dstage[11].id.d0\\}
N 14880 4910 14960 4910 {lab=\\dstage[11].id.d0\\}
N 15290 4400 15380 4400 {lab=\\dstage[11].id.d2\\}
N 15380 4400 15380 4370 {lab=\\dstage[11].id.d2\\}
N 15380 4370 15460 4370 {lab=\\dstage[11].id.d2\\}
N 250 4340 7860 4340 {lab=trim[11]}
N 7860 4340 7860 4410 {lab=trim[11]}
N 7860 4410 15460 4410 {lab=trim[11]}
N 250 4340 500 4340 {lab=trim[11]}
N 15540 4370 15620 4370 {lab=\\dstage[11].id.out\\}
N 15620 4370 15620 4120 {lab=\\dstage[11].id.out\\}
N 15620 4120 15710 4120 {lab=\\dstage[11].id.out\\}
N 14790 3880 14690 3880 {lab=\\dstage[11].id.out\\}
N 14690 3880 14690 3770 {lab=\\dstage[11].id.out\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.out\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.out\\}
N 14810 3790 14690 3790 {lab=\\dstage[11].id.out\\}
N 14690 3790 14690 3770 {lab=\\dstage[11].id.out\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.out\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.out\\}
N 14810 3790 15250 3790 {lab=\\dstage[11].id.out\\}
N 15250 3790 15250 4120 {lab=\\dstage[11].id.out\\}
N 15250 4120 15710 4120 {lab=\\dstage[11].id.out\\}
N 250 5930 7600 5930 {lab=trim[28]}
N 7600 5930 7600 4950 {lab=trim[28]}
N 7600 4950 14960 4950 {lab=trim[28]}
N 250 5930 500 5930 {lab=trim[28]}
N 15040 4910 15120 4910 {lab=\\dstage[11].id.d1\\}
N 15120 4910 15120 4400 {lab=\\dstage[11].id.d1\\}
N 15120 4400 15210 4400 {lab=\\dstage[11].id.d1\\}
N 14790 3880 14690 3880 {lab=\\dstage[11].id.d1\\}
N 14690 3880 14690 3770 {lab=\\dstage[11].id.d1\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.d1\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.d1\\}
N 14810 3790 14690 3790 {lab=\\dstage[11].id.d1\\}
N 14690 3790 14690 3770 {lab=\\dstage[11].id.d1\\}
N 14690 3770 14810 3770 {lab=\\dstage[11].id.d1\\}
N 14810 3770 14810 3790 {lab=\\dstage[11].id.d1\\}
N 14810 3790 15000 3790 {lab=\\dstage[11].id.d1\\}
N 15000 3790 15000 4400 {lab=\\dstage[11].id.d1\\}
N 15000 4400 15210 4400 {lab=\\dstage[11].id.d1\\}
N 15790 4120 15960 4120 {lab=\\dstage[12].id.ts\\}
N 15790 4120 15960 4120 {lab=\\dstage[12].id.ts\\}
N 15790 4120 15960 4120 {lab=\\dstage[12].id.ts\\}
N 16040 4120 15940 4120 {lab=\\dstage[12].id.d0\\}
N 15940 4120 15940 4020 {lab=\\dstage[12].id.d0\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.d0\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.d0\\}
N 16060 4040 15940 4040 {lab=\\dstage[12].id.d0\\}
N 15940 4040 15940 4020 {lab=\\dstage[12].id.d0\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.d0\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.d0\\}
N 16060 4040 16120 4040 {lab=\\dstage[12].id.d0\\}
N 16120 4040 16120 5150 {lab=\\dstage[12].id.d0\\}
N 16120 5150 16210 5150 {lab=\\dstage[12].id.d0\\}
N 16540 4640 16620 4640 {lab=\\dstage[12].id.d2\\}
N 16620 4640 16620 4610 {lab=\\dstage[12].id.d2\\}
N 16620 4610 16710 4610 {lab=\\dstage[12].id.d2\\}
N 250 4590 8480 4590 {lab=trim[12]}
N 8480 4590 8480 4650 {lab=trim[12]}
N 8480 4650 16710 4650 {lab=trim[12]}
N 250 4590 500 4590 {lab=trim[12]}
N 16790 4610 16880 4610 {lab=\\dstage[12].id.out\\}
N 16880 4610 16880 4370 {lab=\\dstage[12].id.out\\}
N 16880 4370 16960 4370 {lab=\\dstage[12].id.out\\}
N 16040 4120 15940 4120 {lab=\\dstage[12].id.out\\}
N 15940 4120 15940 4020 {lab=\\dstage[12].id.out\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.out\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.out\\}
N 16060 4040 15940 4040 {lab=\\dstage[12].id.out\\}
N 15940 4040 15940 4020 {lab=\\dstage[12].id.out\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.out\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.out\\}
N 16060 4040 16500 4040 {lab=\\dstage[12].id.out\\}
N 16500 4040 16500 4370 {lab=\\dstage[12].id.out\\}
N 16500 4370 16960 4370 {lab=\\dstage[12].id.out\\}
N 250 6190 8230 6190 {lab=trim[29]}
N 8230 6190 8230 5190 {lab=trim[29]}
N 8230 5190 16210 5190 {lab=trim[29]}
N 250 6190 500 6190 {lab=trim[29]}
N 16290 5150 16380 5150 {lab=\\dstage[12].id.d1\\}
N 16380 5150 16380 4640 {lab=\\dstage[12].id.d1\\}
N 16380 4640 16460 4640 {lab=\\dstage[12].id.d1\\}
N 16040 4120 15940 4120 {lab=\\dstage[12].id.d1\\}
N 15940 4120 15940 4020 {lab=\\dstage[12].id.d1\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.d1\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.d1\\}
N 16060 4040 15940 4040 {lab=\\dstage[12].id.d1\\}
N 15940 4040 15940 4020 {lab=\\dstage[12].id.d1\\}
N 15940 4020 16060 4020 {lab=\\dstage[12].id.d1\\}
N 16060 4020 16060 4040 {lab=\\dstage[12].id.d1\\}
N 16060 4040 16250 4040 {lab=\\dstage[12].id.d1\\}
N 16250 4040 16250 4640 {lab=\\dstage[12].id.d1\\}
N 16250 4640 16460 4640 {lab=\\dstage[12].id.d1\\}
N 17040 4370 17210 4370 {lab=\\dstage[13].id.ts\\}
N 17040 4370 17210 4370 {lab=\\dstage[13].id.ts\\}
N 17040 4370 17210 4370 {lab=\\dstage[13].id.ts\\}
N 17290 4370 17190 4370 {lab=\\dstage[13].id.d0\\}
N 17190 4370 17190 4270 {lab=\\dstage[13].id.d0\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.d0\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.d0\\}
N 17310 4290 17190 4290 {lab=\\dstage[13].id.d0\\}
N 17190 4290 17190 4270 {lab=\\dstage[13].id.d0\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.d0\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.d0\\}
N 17310 4290 17380 4290 {lab=\\dstage[13].id.d0\\}
N 17380 4290 17380 5400 {lab=\\dstage[13].id.d0\\}
N 17380 5400 17460 5400 {lab=\\dstage[13].id.d0\\}
N 17790 4890 17880 4890 {lab=\\dstage[13].id.d2\\}
N 17880 4890 17880 4860 {lab=\\dstage[13].id.d2\\}
N 17880 4860 17960 4860 {lab=\\dstage[13].id.d2\\}
N 250 4840 9100 4840 {lab=trim[13]}
N 9100 4840 9100 4900 {lab=trim[13]}
N 9100 4900 17960 4900 {lab=trim[13]}
N 250 4840 500 4840 {lab=trim[13]}
N 18040 4860 18120 4860 {lab=\\dstage[13].id.out\\}
N 18120 4860 18120 4620 {lab=\\dstage[13].id.out\\}
N 18120 4620 18210 4620 {lab=\\dstage[13].id.out\\}
N 17290 4370 17190 4370 {lab=\\dstage[13].id.out\\}
N 17190 4370 17190 4270 {lab=\\dstage[13].id.out\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.out\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.out\\}
N 17310 4290 17190 4290 {lab=\\dstage[13].id.out\\}
N 17190 4290 17190 4270 {lab=\\dstage[13].id.out\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.out\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.out\\}
N 17310 4290 17750 4290 {lab=\\dstage[13].id.out\\}
N 17750 4290 17750 4620 {lab=\\dstage[13].id.out\\}
N 17750 4620 18210 4620 {lab=\\dstage[13].id.out\\}
N 250 6440 8860 6440 {lab=trim[30]}
N 8860 6440 8860 5440 {lab=trim[30]}
N 8860 5440 17460 5440 {lab=trim[30]}
N 250 6440 500 6440 {lab=trim[30]}
N 17540 5400 17620 5400 {lab=\\dstage[13].id.d1\\}
N 17620 5400 17620 4890 {lab=\\dstage[13].id.d1\\}
N 17620 4890 17710 4890 {lab=\\dstage[13].id.d1\\}
N 17290 4370 17190 4370 {lab=\\dstage[13].id.d1\\}
N 17190 4370 17190 4270 {lab=\\dstage[13].id.d1\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.d1\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.d1\\}
N 17310 4290 17190 4290 {lab=\\dstage[13].id.d1\\}
N 17190 4290 17190 4270 {lab=\\dstage[13].id.d1\\}
N 17190 4270 17310 4270 {lab=\\dstage[13].id.d1\\}
N 17310 4270 17310 4290 {lab=\\dstage[13].id.d1\\}
N 17310 4290 17500 4290 {lab=\\dstage[13].id.d1\\}
N 17500 4290 17500 4890 {lab=\\dstage[13].id.d1\\}
N 17500 4890 17710 4890 {lab=\\dstage[13].id.d1\\}
N 18290 4620 18460 4620 {lab=\\dstage[14].id.ts\\}
N 18290 4620 18460 4620 {lab=\\dstage[14].id.ts\\}
N 18290 4620 18460 4620 {lab=\\dstage[14].id.ts\\}
N 18540 4620 18440 4620 {lab=\\dstage[14].id.d0\\}
N 18440 4620 18440 4530 {lab=\\dstage[14].id.d0\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.d0\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.d0\\}
N 18560 4550 18440 4550 {lab=\\dstage[14].id.d0\\}
N 18440 4550 18440 4530 {lab=\\dstage[14].id.d0\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.d0\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.d0\\}
N 18560 4550 18620 4550 {lab=\\dstage[14].id.d0\\}
N 18620 4550 18620 5650 {lab=\\dstage[14].id.d0\\}
N 18620 5650 18710 5650 {lab=\\dstage[14].id.d0\\}
N 19040 5130 19120 5130 {lab=\\dstage[14].id.d2\\}
N 19120 5130 19120 5110 {lab=\\dstage[14].id.d2\\}
N 19120 5110 19210 5110 {lab=\\dstage[14].id.d2\\}
N 250 5090 9730 5090 {lab=trim[14]}
N 9730 5090 9730 5150 {lab=trim[14]}
N 9730 5150 19210 5150 {lab=trim[14]}
N 250 5090 500 5090 {lab=trim[14]}
N 19290 5110 19380 5110 {lab=\\dstage[14].id.out\\}
N 19380 5110 19380 4860 {lab=\\dstage[14].id.out\\}
N 19380 4860 19460 4860 {lab=\\dstage[14].id.out\\}
N 18540 4620 18440 4620 {lab=\\dstage[14].id.out\\}
N 18440 4620 18440 4530 {lab=\\dstage[14].id.out\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.out\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.out\\}
N 18560 4550 18440 4550 {lab=\\dstage[14].id.out\\}
N 18440 4550 18440 4530 {lab=\\dstage[14].id.out\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.out\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.out\\}
N 18560 4550 19000 4550 {lab=\\dstage[14].id.out\\}
N 19000 4550 19000 4860 {lab=\\dstage[14].id.out\\}
N 19000 4860 19460 4860 {lab=\\dstage[14].id.out\\}
N 250 6690 9480 6690 {lab=trim[31]}
N 9480 6690 9480 5690 {lab=trim[31]}
N 9480 5690 18710 5690 {lab=trim[31]}
N 250 6690 500 6690 {lab=trim[31]}
N 18790 5650 18880 5650 {lab=\\dstage[14].id.d1\\}
N 18880 5650 18880 5130 {lab=\\dstage[14].id.d1\\}
N 18880 5130 18960 5130 {lab=\\dstage[14].id.d1\\}
N 18540 4620 18440 4620 {lab=\\dstage[14].id.d1\\}
N 18440 4620 18440 4530 {lab=\\dstage[14].id.d1\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.d1\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.d1\\}
N 18560 4550 18440 4550 {lab=\\dstage[14].id.d1\\}
N 18440 4550 18440 4530 {lab=\\dstage[14].id.d1\\}
N 18440 4530 18560 4530 {lab=\\dstage[14].id.d1\\}
N 18560 4530 18560 4550 {lab=\\dstage[14].id.d1\\}
N 18560 4550 18750 4550 {lab=\\dstage[14].id.d1\\}
N 18750 4550 18750 5130 {lab=\\dstage[14].id.d1\\}
N 18750 5130 18960 5130 {lab=\\dstage[14].id.d1\\}
N 19540 4860 19710 4860 {lab=\\dstage[15].id.ts\\}
N 19540 4860 9860 4860 {lab=\\dstage[15].id.ts\\}
N 9860 4860 9860 250 {lab=\\dstage[15].id.ts\\}
N 9860 250 440 250 {lab=\\dstage[15].id.ts\\}
N 440 250 440 230 {lab=\\dstage[15].id.ts\\}
N 440 230 560 230 {lab=\\dstage[15].id.ts\\}
N 560 230 560 4800 {lab=\\dstage[15].id.ts\\}
N 560 4800 210 4800 {lab=\\dstage[15].id.ts\\}
N 19540 4860 19710 4860 {lab=\\dstage[15].id.ts\\}
N 19790 4860 19690 4860 {lab=\\dstage[15].id.d0\\}
N 19690 4860 19690 4780 {lab=\\dstage[15].id.d0\\}
N 19690 4780 19810 4780 {lab=\\dstage[15].id.d0\\}
N 19810 4780 19810 4800 {lab=\\dstage[15].id.d0\\}
N 19810 4800 19880 4800 {lab=\\dstage[15].id.d0\\}
N 19880 4800 19880 5900 {lab=\\dstage[15].id.d0\\}
N 19880 5900 19960 5900 {lab=\\dstage[15].id.d0\\}
N 20290 5380 20380 5380 {lab=\\dstage[15].id.d2\\}
N 20380 5380 20380 5360 {lab=\\dstage[15].id.d2\\}
N 20380 5360 20460 5360 {lab=\\dstage[15].id.d2\\}
N 250 5340 10360 5340 {lab=trim[15]}
N 10360 5340 10360 5400 {lab=trim[15]}
N 10360 5400 20460 5400 {lab=trim[15]}
N 250 5340 500 5340 {lab=trim[15]}
N 20540 5360 20640 5360 {lab=\\dstage[15].id.out\\}
N 20640 5360 20640 2770 {lab=\\dstage[15].id.out\\}
N 20640 2770 20690 2770 {lab=\\dstage[15].id.out\\}
N 20690 2770 20690 2750 {lab=\\dstage[15].id.out\\}
N 20690 2750 20810 2750 {lab=\\dstage[15].id.out\\}
N 20810 2750 20810 5080 {lab=\\dstage[15].id.out\\}
N 20810 5080 20710 5080 {lab=\\dstage[15].id.out\\}
N 20540 5360 10480 5360 {lab=\\dstage[15].id.out\\}
N 10480 5360 10440 5300 {lab=\\dstage[15].id.out\\}
N 10440 5300 10440 3260 {lab=\\dstage[15].id.out\\}
N 10440 3260 10560 3260 {lab=\\dstage[15].id.out\\}
N 10560 3260 10560 250 {lab=\\dstage[15].id.out\\}
N 10560 250 10480 5050 {lab=\\dstage[15].id.out\\}
N 10480 5050 460 5050 {lab=\\dstage[15].id.out\\}
N 20540 5360 20620 5360 {lab=\\dstage[15].id.out\\}
N 20620 5360 20620 2770 {lab=\\dstage[15].id.out\\}
N 20620 2770 20690 2770 {lab=\\dstage[15].id.out\\}
N 20690 2770 20690 2750 {lab=\\dstage[15].id.out\\}
N 20690 2750 20810 2750 {lab=\\dstage[15].id.out\\}
N 20810 2750 20810 5080 {lab=\\dstage[15].id.out\\}
N 20810 5080 20710 5080 {lab=\\dstage[15].id.out\\}
N 290 4800 440 4800 {lab=\\dstage[15].id.out\\}
N 440 4800 440 230 {lab=\\dstage[15].id.out\\}
N 440 230 560 230 {lab=\\dstage[15].id.out\\}
N 560 230 560 250 {lab=\\dstage[15].id.out\\}
N 560 250 10520 250 {lab=\\dstage[15].id.out\\}
N 10520 250 10520 2770 {lab=\\dstage[15].id.out\\}
N 10520 2770 20690 2770 {lab=\\dstage[15].id.out\\}
N 20690 2770 20690 2750 {lab=\\dstage[15].id.out\\}
N 20690 2750 20810 2750 {lab=\\dstage[15].id.out\\}
N 20810 2750 20810 5080 {lab=\\dstage[15].id.out\\}
N 20810 5080 20710 5080 {lab=\\dstage[15].id.out\\}
N 290 4800 380 4800 {lab=\\dstage[15].id.out\\}
N 380 4800 380 5050 {lab=\\dstage[15].id.out\\}
N 380 5050 460 5050 {lab=\\dstage[15].id.out\\}
N 290 4800 440 4800 {lab=\\dstage[15].id.out\\}
N 440 4800 440 230 {lab=\\dstage[15].id.out\\}
N 440 230 560 230 {lab=\\dstage[15].id.out\\}
N 560 230 560 250 {lab=\\dstage[15].id.out\\}
N 560 250 10500 250 {lab=\\dstage[15].id.out\\}
N 10500 250 10500 2770 {lab=\\dstage[15].id.out\\}
N 10500 2770 20690 2770 {lab=\\dstage[15].id.out\\}
N 20690 2770 20690 2750 {lab=\\dstage[15].id.out\\}
N 20690 2750 20810 2750 {lab=\\dstage[15].id.out\\}
N 20810 2750 20810 5080 {lab=\\dstage[15].id.out\\}
N 20810 5080 20710 5080 {lab=\\dstage[15].id.out\\}
N 250 6940 10100 6940 {lab=trim[32]}
N 10100 6940 10100 5940 {lab=trim[32]}
N 10100 5940 19960 5940 {lab=trim[32]}
N 250 6940 500 6940 {lab=trim[32]}
N 20040 5900 20120 5900 {lab=\\dstage[15].id.d1\\}
N 20120 5900 20120 5380 {lab=\\dstage[15].id.d1\\}
N 20120 5380 20210 5380 {lab=\\dstage[15].id.d1\\}
N 19790 4860 19690 4860 {lab=\\dstage[15].id.d1\\}
N 19690 4860 19690 4780 {lab=\\dstage[15].id.d1\\}
N 19690 4780 19810 4780 {lab=\\dstage[15].id.d1\\}
N 19810 4780 19810 4800 {lab=\\dstage[15].id.d1\\}
N 19810 4800 20000 4800 {lab=\\dstage[15].id.d1\\}
N 20000 4800 20000 5380 {lab=\\dstage[15].id.d1\\}
N 20000 5380 20210 5380 {lab=\\dstage[15].id.d1\\}
N 2040 3130 2210 3130 {lab=\\dstage[1].id.ts\\}
N 2040 3130 2210 3130 {lab=\\dstage[1].id.ts\\}
N 2040 3130 2210 3130 {lab=\\dstage[1].id.ts\\}
N 2290 3130 2190 3130 {lab=\\dstage[1].id.d0\\}
N 2190 3130 2190 820 {lab=\\dstage[1].id.d0\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.d0\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.d0\\}
N 2310 840 2190 840 {lab=\\dstage[1].id.d0\\}
N 2190 840 2190 820 {lab=\\dstage[1].id.d0\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.d0\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.d0\\}
N 2310 840 2380 840 {lab=\\dstage[1].id.d0\\}
N 2380 840 2380 3170 {lab=\\dstage[1].id.d0\\}
N 2380 3170 2460 3170 {lab=\\dstage[1].id.d0\\}
N 2790 3150 2880 3150 {lab=\\dstage[1].id.d2\\}
N 2880 3150 2880 2410 {lab=\\dstage[1].id.d2\\}
N 2880 2410 2960 2410 {lab=\\dstage[1].id.d2\\}
N 250 1670 1600 1670 {lab=trim[1]}
N 1600 1670 1600 2450 {lab=trim[1]}
N 1600 2450 2960 2450 {lab=trim[1]}
N 250 1670 500 1670 {lab=trim[1]}
N 3040 2410 3120 2410 {lab=\\dstage[1].id.out\\}
N 3120 2410 3120 2770 {lab=\\dstage[1].id.out\\}
N 3120 2770 3210 2770 {lab=\\dstage[1].id.out\\}
N 2290 3130 2190 3130 {lab=\\dstage[1].id.out\\}
N 2190 3130 2190 820 {lab=\\dstage[1].id.out\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.out\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.out\\}
N 2310 840 2190 840 {lab=\\dstage[1].id.out\\}
N 2190 840 2190 820 {lab=\\dstage[1].id.out\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.out\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.out\\}
N 2310 840 2750 840 {lab=\\dstage[1].id.out\\}
N 2750 840 2750 2770 {lab=\\dstage[1].id.out\\}
N 2750 2770 3210 2770 {lab=\\dstage[1].id.out\\}
N 250 3210 1360 3210 {lab=trim[18]}
N 1360 3210 1360 3210 {lab=trim[18]}
N 1360 3210 2460 3210 {lab=trim[18]}
N 250 3210 500 3210 {lab=trim[18]}
N 2540 3170 2620 3170 {lab=\\dstage[1].id.d1\\}
N 2620 3170 2620 3150 {lab=\\dstage[1].id.d1\\}
N 2620 3150 2710 3150 {lab=\\dstage[1].id.d1\\}
N 2290 3130 2190 3130 {lab=\\dstage[1].id.d1\\}
N 2190 3130 2190 820 {lab=\\dstage[1].id.d1\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.d1\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.d1\\}
N 2310 840 2190 840 {lab=\\dstage[1].id.d1\\}
N 2190 840 2190 820 {lab=\\dstage[1].id.d1\\}
N 2190 820 2310 820 {lab=\\dstage[1].id.d1\\}
N 2310 820 2310 840 {lab=\\dstage[1].id.d1\\}
N 2310 840 2500 840 {lab=\\dstage[1].id.d1\\}
N 2500 840 2500 3150 {lab=\\dstage[1].id.d1\\}
N 2500 3150 2710 3150 {lab=\\dstage[1].id.d1\\}
N 3290 2770 3460 2770 {lab=\\dstage[2].id.ts\\}
N 3290 2770 3460 2770 {lab=\\dstage[2].id.ts\\}
N 3290 2770 3460 2770 {lab=\\dstage[2].id.ts\\}
N 3540 2770 3440 2770 {lab=\\dstage[2].id.d0\\}
N 3440 2770 3440 1210 {lab=\\dstage[2].id.d0\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.d0\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.d0\\}
N 3560 1230 3440 1230 {lab=\\dstage[2].id.d0\\}
N 3440 1230 3440 1210 {lab=\\dstage[2].id.d0\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.d0\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.d0\\}
N 3560 1230 3620 1230 {lab=\\dstage[2].id.d0\\}
N 3620 1230 3620 3150 {lab=\\dstage[2].id.d0\\}
N 3620 3150 3710 3150 {lab=\\dstage[2].id.d0\\}
N 4040 2960 4120 2960 {lab=\\dstage[2].id.d2\\}
N 4120 2960 4120 2460 {lab=\\dstage[2].id.d2\\}
N 4120 2460 4210 2460 {lab=\\dstage[2].id.d2\\}
N 250 1970 2230 1970 {lab=trim[2]}
N 2230 1970 2230 2500 {lab=trim[2]}
N 2230 2500 4210 2500 {lab=trim[2]}
N 250 1970 500 1970 {lab=trim[2]}
N 4290 2460 4380 2460 {lab=\\dstage[2].id.out\\}
N 4380 2460 4380 2620 {lab=\\dstage[2].id.out\\}
N 4380 2620 4460 2620 {lab=\\dstage[2].id.out\\}
N 3540 2770 3440 2770 {lab=\\dstage[2].id.out\\}
N 3440 2770 3440 1210 {lab=\\dstage[2].id.out\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.out\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.out\\}
N 3560 1230 3440 1230 {lab=\\dstage[2].id.out\\}
N 3440 1230 3440 1210 {lab=\\dstage[2].id.out\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.out\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.out\\}
N 3560 1230 4000 1230 {lab=\\dstage[2].id.out\\}
N 4000 1230 4000 2620 {lab=\\dstage[2].id.out\\}
N 4000 2620 4460 2620 {lab=\\dstage[2].id.out\\}
N 250 3530 1980 3530 {lab=trim[19]}
N 1980 3530 1980 3190 {lab=trim[19]}
N 1980 3190 3710 3190 {lab=trim[19]}
N 250 3530 500 3530 {lab=trim[19]}
N 3790 3150 3880 3150 {lab=\\dstage[2].id.d1\\}
N 3880 3150 3880 2960 {lab=\\dstage[2].id.d1\\}
N 3880 2960 3960 2960 {lab=\\dstage[2].id.d1\\}
N 3540 2770 3440 2770 {lab=\\dstage[2].id.d1\\}
N 3440 2770 3440 1210 {lab=\\dstage[2].id.d1\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.d1\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.d1\\}
N 3560 1230 3440 1230 {lab=\\dstage[2].id.d1\\}
N 3440 1230 3440 1210 {lab=\\dstage[2].id.d1\\}
N 3440 1210 3560 1210 {lab=\\dstage[2].id.d1\\}
N 3560 1210 3560 1230 {lab=\\dstage[2].id.d1\\}
N 3560 1230 3750 1230 {lab=\\dstage[2].id.d1\\}
N 3750 1230 3750 2960 {lab=\\dstage[2].id.d1\\}
N 3750 2960 3960 2960 {lab=\\dstage[2].id.d1\\}
N 4540 2620 4710 2620 {lab=\\dstage[3].id.ts\\}
N 4540 2620 4710 2620 {lab=\\dstage[3].id.ts\\}
N 4540 2620 4710 2620 {lab=\\dstage[3].id.ts\\}
N 4790 2620 4690 2620 {lab=\\dstage[3].id.d0\\}
N 4690 2620 4690 1560 {lab=\\dstage[3].id.d0\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.d0\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.d0\\}
N 4810 1580 4690 1580 {lab=\\dstage[3].id.d0\\}
N 4690 1580 4690 1560 {lab=\\dstage[3].id.d0\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.d0\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.d0\\}
N 4810 1580 4880 1580 {lab=\\dstage[3].id.d0\\}
N 4880 1580 4880 3220 {lab=\\dstage[3].id.d0\\}
N 4880 3220 4960 3220 {lab=\\dstage[3].id.d0\\}
N 5290 2920 5380 2920 {lab=\\dstage[3].id.d2\\}
N 5380 2920 5380 2590 {lab=\\dstage[3].id.d2\\}
N 5380 2590 5460 2590 {lab=\\dstage[3].id.d2\\}
N 250 2260 2860 2260 {lab=trim[3]}
N 2860 2260 2860 2630 {lab=trim[3]}
N 2860 2630 5460 2630 {lab=trim[3]}
N 250 2260 500 2260 {lab=trim[3]}
N 5540 2590 5620 2590 {lab=\\dstage[3].id.out\\}
N 5620 2590 5620 2600 {lab=\\dstage[3].id.out\\}
N 5620 2600 5710 2600 {lab=\\dstage[3].id.out\\}
N 4790 2620 4690 2620 {lab=\\dstage[3].id.out\\}
N 4690 2620 4690 1560 {lab=\\dstage[3].id.out\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.out\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.out\\}
N 4810 1580 4690 1580 {lab=\\dstage[3].id.out\\}
N 4690 1580 4690 1560 {lab=\\dstage[3].id.out\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.out\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.out\\}
N 4810 1580 5250 1580 {lab=\\dstage[3].id.out\\}
N 5250 1580 5250 2600 {lab=\\dstage[3].id.out\\}
N 5250 2600 5710 2600 {lab=\\dstage[3].id.out\\}
N 250 3830 2600 3830 {lab=trim[20]}
N 2600 3830 2600 3260 {lab=trim[20]}
N 2600 3260 4960 3260 {lab=trim[20]}
N 250 3830 500 3830 {lab=trim[20]}
N 5040 3220 5120 3220 {lab=\\dstage[3].id.d1\\}
N 5120 3220 5120 2920 {lab=\\dstage[3].id.d1\\}
N 5120 2920 5210 2920 {lab=\\dstage[3].id.d1\\}
N 4790 2620 4690 2620 {lab=\\dstage[3].id.d1\\}
N 4690 2620 4690 1560 {lab=\\dstage[3].id.d1\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.d1\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.d1\\}
N 4810 1580 4690 1580 {lab=\\dstage[3].id.d1\\}
N 4690 1580 4690 1560 {lab=\\dstage[3].id.d1\\}
N 4690 1560 4810 1560 {lab=\\dstage[3].id.d1\\}
N 4810 1560 4810 1580 {lab=\\dstage[3].id.d1\\}
N 4810 1580 5000 1580 {lab=\\dstage[3].id.d1\\}
N 5000 1580 5000 2920 {lab=\\dstage[3].id.d1\\}
N 5000 2920 5210 2920 {lab=\\dstage[3].id.d1\\}
N 5790 2600 5960 2600 {lab=\\dstage[4].id.ts\\}
N 5790 2600 5960 2600 {lab=\\dstage[4].id.ts\\}
N 5790 2600 5960 2600 {lab=\\dstage[4].id.ts\\}
N 6040 2600 5940 2600 {lab=\\dstage[4].id.d0\\}
N 5940 2600 5940 1880 {lab=\\dstage[4].id.d0\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.d0\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.d0\\}
N 6060 1900 5940 1900 {lab=\\dstage[4].id.d0\\}
N 5940 1900 5940 1880 {lab=\\dstage[4].id.d0\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.d0\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.d0\\}
N 6060 1900 6120 1900 {lab=\\dstage[4].id.d0\\}
N 6120 1900 6120 3360 {lab=\\dstage[4].id.d0\\}
N 6120 3360 6210 3360 {lab=\\dstage[4].id.d0\\}
N 6540 2980 6620 2980 {lab=\\dstage[4].id.d2\\}
N 6620 2980 6620 2760 {lab=\\dstage[4].id.d2\\}
N 6620 2760 6710 2760 {lab=\\dstage[4].id.d2\\}
N 250 2530 3480 2530 {lab=trim[4]}
N 3480 2530 3480 2800 {lab=trim[4]}
N 3480 2800 6710 2800 {lab=trim[4]}
N 250 2530 500 2530 {lab=trim[4]}
N 6790 2760 6880 2760 {lab=\\dstage[4].id.out\\}
N 6880 2760 6880 2680 {lab=\\dstage[4].id.out\\}
N 6880 2680 6960 2680 {lab=\\dstage[4].id.out\\}
N 6040 2600 5940 2600 {lab=\\dstage[4].id.out\\}
N 5940 2600 5940 1880 {lab=\\dstage[4].id.out\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.out\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.out\\}
N 6060 1900 5940 1900 {lab=\\dstage[4].id.out\\}
N 5940 1900 5940 1880 {lab=\\dstage[4].id.out\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.out\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.out\\}
N 6060 1900 6500 1900 {lab=\\dstage[4].id.out\\}
N 6500 1900 6500 2680 {lab=\\dstage[4].id.out\\}
N 6500 2680 6960 2680 {lab=\\dstage[4].id.out\\}
N 250 4110 3230 4110 {lab=trim[21]}
N 3230 4110 3230 3400 {lab=trim[21]}
N 3230 3400 6210 3400 {lab=trim[21]}
N 250 4110 500 4110 {lab=trim[21]}
N 6290 3360 6380 3360 {lab=\\dstage[4].id.d1\\}
N 6380 3360 6380 2980 {lab=\\dstage[4].id.d1\\}
N 6380 2980 6460 2980 {lab=\\dstage[4].id.d1\\}
N 6040 2600 5940 2600 {lab=\\dstage[4].id.d1\\}
N 5940 2600 5940 1880 {lab=\\dstage[4].id.d1\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.d1\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.d1\\}
N 6060 1900 5940 1900 {lab=\\dstage[4].id.d1\\}
N 5940 1900 5940 1880 {lab=\\dstage[4].id.d1\\}
N 5940 1880 6060 1880 {lab=\\dstage[4].id.d1\\}
N 6060 1880 6060 1900 {lab=\\dstage[4].id.d1\\}
N 6060 1900 6250 1900 {lab=\\dstage[4].id.d1\\}
N 6250 1900 6250 2980 {lab=\\dstage[4].id.d1\\}
N 6250 2980 6460 2980 {lab=\\dstage[4].id.d1\\}
N 7040 2680 7210 2680 {lab=\\dstage[5].id.ts\\}
N 7040 2680 7210 2680 {lab=\\dstage[5].id.ts\\}
N 7040 2680 7210 2680 {lab=\\dstage[5].id.ts\\}
N 7290 2680 7190 2680 {lab=\\dstage[5].id.d0\\}
N 7190 2680 7190 2180 {lab=\\dstage[5].id.d0\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.d0\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.d0\\}
N 7310 2200 7190 2200 {lab=\\dstage[5].id.d0\\}
N 7190 2200 7190 2180 {lab=\\dstage[5].id.d0\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.d0\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.d0\\}
N 7310 2200 7380 2200 {lab=\\dstage[5].id.d0\\}
N 7380 2200 7380 3530 {lab=\\dstage[5].id.d0\\}
N 7380 3530 7460 3530 {lab=\\dstage[5].id.d0\\}
N 7790 3110 7880 3110 {lab=\\dstage[5].id.d2\\}
N 7880 3110 7880 2950 {lab=\\dstage[5].id.d2\\}
N 7880 2950 7960 2950 {lab=\\dstage[5].id.d2\\}
N 250 2800 4100 2800 {lab=trim[5]}
N 4100 2800 4100 2990 {lab=trim[5]}
N 4100 2990 7960 2990 {lab=trim[5]}
N 250 2800 500 2800 {lab=trim[5]}
N 8040 2950 8120 2950 {lab=\\dstage[5].id.out\\}
N 8120 2950 8120 2820 {lab=\\dstage[5].id.out\\}
N 8120 2820 8210 2820 {lab=\\dstage[5].id.out\\}
N 7290 2680 7190 2680 {lab=\\dstage[5].id.out\\}
N 7190 2680 7190 2180 {lab=\\dstage[5].id.out\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.out\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.out\\}
N 7310 2200 7190 2200 {lab=\\dstage[5].id.out\\}
N 7190 2200 7190 2180 {lab=\\dstage[5].id.out\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.out\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.out\\}
N 7310 2200 7750 2200 {lab=\\dstage[5].id.out\\}
N 7750 2200 7750 2820 {lab=\\dstage[5].id.out\\}
N 7750 2820 8210 2820 {lab=\\dstage[5].id.out\\}
N 250 4390 3860 4390 {lab=trim[22]}
N 3860 4390 3860 3570 {lab=trim[22]}
N 3860 3570 7460 3570 {lab=trim[22]}
N 250 4390 500 4390 {lab=trim[22]}
N 7540 3530 7620 3530 {lab=\\dstage[5].id.d1\\}
N 7620 3530 7620 3110 {lab=\\dstage[5].id.d1\\}
N 7620 3110 7710 3110 {lab=\\dstage[5].id.d1\\}
N 7290 2680 7190 2680 {lab=\\dstage[5].id.d1\\}
N 7190 2680 7190 2180 {lab=\\dstage[5].id.d1\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.d1\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.d1\\}
N 7310 2200 7190 2200 {lab=\\dstage[5].id.d1\\}
N 7190 2200 7190 2180 {lab=\\dstage[5].id.d1\\}
N 7190 2180 7310 2180 {lab=\\dstage[5].id.d1\\}
N 7310 2180 7310 2200 {lab=\\dstage[5].id.d1\\}
N 7310 2200 7500 2200 {lab=\\dstage[5].id.d1\\}
N 7500 2200 7500 3110 {lab=\\dstage[5].id.d1\\}
N 7500 3110 7710 3110 {lab=\\dstage[5].id.d1\\}
N 8290 2820 8460 2820 {lab=\\dstage[6].id.ts\\}
N 8290 2820 8460 2820 {lab=\\dstage[6].id.ts\\}
N 8290 2820 8460 2820 {lab=\\dstage[6].id.ts\\}
N 8540 2820 8440 2820 {lab=\\dstage[6].id.d0\\}
N 8440 2820 8440 2460 {lab=\\dstage[6].id.d0\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.d0\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.d0\\}
N 8560 2480 8440 2480 {lab=\\dstage[6].id.d0\\}
N 8440 2480 8440 2460 {lab=\\dstage[6].id.d0\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.d0\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.d0\\}
N 8560 2480 8620 2480 {lab=\\dstage[6].id.d0\\}
N 8620 2480 8620 3740 {lab=\\dstage[6].id.d0\\}
N 8620 3740 8710 3740 {lab=\\dstage[6].id.d0\\}
N 9040 3280 9120 3280 {lab=\\dstage[6].id.d2\\}
N 9120 3280 9120 3170 {lab=\\dstage[6].id.d2\\}
N 9120 3170 9210 3170 {lab=\\dstage[6].id.d2\\}
N 250 3060 4730 3060 {lab=trim[6]}
N 4730 3060 4730 3210 {lab=trim[6]}
N 4730 3210 9210 3210 {lab=trim[6]}
N 250 3060 500 3060 {lab=trim[6]}
N 9290 3170 9380 3170 {lab=\\dstage[6].id.out\\}
N 9380 3170 9380 2990 {lab=\\dstage[6].id.out\\}
N 9380 2990 9460 2990 {lab=\\dstage[6].id.out\\}
N 8540 2820 8440 2820 {lab=\\dstage[6].id.out\\}
N 8440 2820 8440 2460 {lab=\\dstage[6].id.out\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.out\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.out\\}
N 8560 2480 8440 2480 {lab=\\dstage[6].id.out\\}
N 8440 2480 8440 2460 {lab=\\dstage[6].id.out\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.out\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.out\\}
N 8560 2480 9000 2480 {lab=\\dstage[6].id.out\\}
N 9000 2480 9000 2990 {lab=\\dstage[6].id.out\\}
N 9000 2990 9460 2990 {lab=\\dstage[6].id.out\\}
N 250 4650 4480 4650 {lab=trim[23]}
N 4480 4650 4480 3780 {lab=trim[23]}
N 4480 3780 8710 3780 {lab=trim[23]}
N 250 4650 500 4650 {lab=trim[23]}
N 8790 3740 8880 3740 {lab=\\dstage[6].id.d1\\}
N 8880 3740 8880 3280 {lab=\\dstage[6].id.d1\\}
N 8880 3280 8960 3280 {lab=\\dstage[6].id.d1\\}
N 8540 2820 8440 2820 {lab=\\dstage[6].id.d1\\}
N 8440 2820 8440 2460 {lab=\\dstage[6].id.d1\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.d1\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.d1\\}
N 8560 2480 8440 2480 {lab=\\dstage[6].id.d1\\}
N 8440 2480 8440 2460 {lab=\\dstage[6].id.d1\\}
N 8440 2460 8560 2460 {lab=\\dstage[6].id.d1\\}
N 8560 2460 8560 2480 {lab=\\dstage[6].id.d1\\}
N 8560 2480 8750 2480 {lab=\\dstage[6].id.d1\\}
N 8750 2480 8750 3280 {lab=\\dstage[6].id.d1\\}
N 8750 3280 8960 3280 {lab=\\dstage[6].id.d1\\}
N 9540 2990 9710 2990 {lab=\\dstage[7].id.ts\\}
N 9540 2990 9710 2990 {lab=\\dstage[7].id.ts\\}
N 9540 2990 9710 2990 {lab=\\dstage[7].id.ts\\}
N 9790 2990 9690 2990 {lab=\\dstage[7].id.d0\\}
N 9690 2990 9690 2730 {lab=\\dstage[7].id.d0\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.d0\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.d0\\}
N 9810 2750 9690 2750 {lab=\\dstage[7].id.d0\\}
N 9690 2750 9690 2730 {lab=\\dstage[7].id.d0\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.d0\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.d0\\}
N 9810 2750 9880 2750 {lab=\\dstage[7].id.d0\\}
N 9880 2750 9880 3950 {lab=\\dstage[7].id.d0\\}
N 9880 3950 9960 3950 {lab=\\dstage[7].id.d0\\}
N 10290 3470 10380 3470 {lab=\\dstage[7].id.d2\\}
N 10380 3470 10380 3400 {lab=\\dstage[7].id.d2\\}
N 10380 3400 10460 3400 {lab=\\dstage[7].id.d2\\}
N 250 3320 5360 3320 {lab=trim[7]}
N 5360 3320 5360 3440 {lab=trim[7]}
N 5360 3440 10460 3440 {lab=trim[7]}
N 250 3320 500 3320 {lab=trim[7]}
N 10540 3400 10640 3400 {lab=\\dstage[7].id.out\\}
N 10640 3400 10640 3020 {lab=\\dstage[7].id.out\\}
N 10640 3020 10690 3020 {lab=\\dstage[7].id.out\\}
N 10690 3020 10690 3000 {lab=\\dstage[7].id.out\\}
N 10690 3000 10810 3000 {lab=\\dstage[7].id.out\\}
N 10810 3000 10810 3200 {lab=\\dstage[7].id.out\\}
N 10810 3200 10710 3200 {lab=\\dstage[7].id.out\\}
N 10540 3400 10620 3400 {lab=\\dstage[7].id.out\\}
N 10620 3400 10620 3020 {lab=\\dstage[7].id.out\\}
N 10620 3020 10690 3020 {lab=\\dstage[7].id.out\\}
N 10690 3020 10690 3000 {lab=\\dstage[7].id.out\\}
N 10690 3000 10810 3000 {lab=\\dstage[7].id.out\\}
N 10810 3000 10810 3200 {lab=\\dstage[7].id.out\\}
N 10810 3200 10710 3200 {lab=\\dstage[7].id.out\\}
N 9790 2990 9690 2990 {lab=\\dstage[7].id.out\\}
N 9690 2990 9690 2730 {lab=\\dstage[7].id.out\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.out\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.out\\}
N 9810 2750 9690 2750 {lab=\\dstage[7].id.out\\}
N 9690 2750 9690 2730 {lab=\\dstage[7].id.out\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.out\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.out\\}
N 9810 2750 10260 2750 {lab=\\dstage[7].id.out\\}
N 10260 2750 10260 3020 {lab=\\dstage[7].id.out\\}
N 10260 3020 10690 3020 {lab=\\dstage[7].id.out\\}
N 10690 3020 10690 3000 {lab=\\dstage[7].id.out\\}
N 10690 3000 10810 3000 {lab=\\dstage[7].id.out\\}
N 10810 3000 10810 3200 {lab=\\dstage[7].id.out\\}
N 10810 3200 10710 3200 {lab=\\dstage[7].id.out\\}
N 9790 2990 9690 2990 {lab=\\dstage[7].id.out\\}
N 9690 2990 9690 2730 {lab=\\dstage[7].id.out\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.out\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.out\\}
N 9810 2750 9690 2750 {lab=\\dstage[7].id.out\\}
N 9690 2750 9690 2730 {lab=\\dstage[7].id.out\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.out\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.out\\}
N 9810 2750 10240 2750 {lab=\\dstage[7].id.out\\}
N 10240 2750 10240 3020 {lab=\\dstage[7].id.out\\}
N 10240 3020 10690 3020 {lab=\\dstage[7].id.out\\}
N 10690 3020 10690 3000 {lab=\\dstage[7].id.out\\}
N 10690 3000 10810 3000 {lab=\\dstage[7].id.out\\}
N 10810 3000 10810 3200 {lab=\\dstage[7].id.out\\}
N 10810 3200 10710 3200 {lab=\\dstage[7].id.out\\}
N 250 4920 5100 4920 {lab=trim[24]}
N 5100 4920 5100 3990 {lab=trim[24]}
N 5100 3990 9960 3990 {lab=trim[24]}
N 250 4920 500 4920 {lab=trim[24]}
N 10040 3950 10120 3950 {lab=\\dstage[7].id.d1\\}
N 10120 3950 10120 3470 {lab=\\dstage[7].id.d1\\}
N 10120 3470 10210 3470 {lab=\\dstage[7].id.d1\\}
N 9790 2990 9690 2990 {lab=\\dstage[7].id.d1\\}
N 9690 2990 9690 2730 {lab=\\dstage[7].id.d1\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.d1\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.d1\\}
N 9810 2750 9690 2750 {lab=\\dstage[7].id.d1\\}
N 9690 2750 9690 2730 {lab=\\dstage[7].id.d1\\}
N 9690 2730 9810 2730 {lab=\\dstage[7].id.d1\\}
N 9810 2730 9810 2750 {lab=\\dstage[7].id.d1\\}
N 9810 2750 10000 2750 {lab=\\dstage[7].id.d1\\}
N 10000 2750 10000 3470 {lab=\\dstage[7].id.d1\\}
N 10000 3470 10210 3470 {lab=\\dstage[7].id.d1\\}
N 10790 3200 10960 3200 {lab=\\dstage[8].id.ts\\}
N 10790 3200 10960 3200 {lab=\\dstage[8].id.ts\\}
N 10790 3200 10960 3200 {lab=\\dstage[8].id.ts\\}
N 11040 3200 10940 3200 {lab=\\dstage[8].id.d0\\}
N 10940 3200 10940 3000 {lab=\\dstage[8].id.d0\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d0\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d0\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.d0\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.d0\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d0\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d0\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.d0\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.d0\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d0\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d0\\}
N 11060 3020 11140 3020 {lab=\\dstage[8].id.d0\\}
N 11140 3020 11140 4180 {lab=\\dstage[8].id.d0\\}
N 11140 4180 11210 4180 {lab=\\dstage[8].id.d0\\}
N 11540 3690 11620 3690 {lab=\\dstage[8].id.d2\\}
N 11620 3690 11620 3630 {lab=\\dstage[8].id.d2\\}
N 11620 3630 11710 3630 {lab=\\dstage[8].id.d2\\}
N 250 3580 5980 3580 {lab=trim[8]}
N 5980 3580 5980 3670 {lab=trim[8]}
N 5980 3670 11710 3670 {lab=trim[8]}
N 250 3580 500 3580 {lab=trim[8]}
N 11790 3630 11880 3630 {lab=\\dstage[8].id.out\\}
N 11880 3630 11880 3410 {lab=\\dstage[8].id.out\\}
N 11880 3410 11960 3410 {lab=\\dstage[8].id.out\\}
N 11040 3200 10940 3200 {lab=\\dstage[8].id.out\\}
N 10940 3200 10940 3000 {lab=\\dstage[8].id.out\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.out\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.out\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.out\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.out\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.out\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.out\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.out\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.out\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.out\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.out\\}
N 11060 3020 11190 3020 {lab=\\dstage[8].id.out\\}
N 11190 3020 11190 3000 {lab=\\dstage[8].id.out\\}
N 11190 3000 11310 3000 {lab=\\dstage[8].id.out\\}
N 11310 3000 11310 3020 {lab=\\dstage[8].id.out\\}
N 11310 3020 11480 3020 {lab=\\dstage[8].id.out\\}
N 11480 3020 11480 3040 {lab=\\dstage[8].id.out\\}
N 11480 3040 11520 3040 {lab=\\dstage[8].id.out\\}
N 11520 3040 11520 3280 {lab=\\dstage[8].id.out\\}
N 11520 3280 11500 3410 {lab=\\dstage[8].id.out\\}
N 11500 3410 11960 3410 {lab=\\dstage[8].id.out\\}
N 250 5170 5730 5170 {lab=trim[25]}
N 5730 5170 5730 4220 {lab=trim[25]}
N 5730 4220 11210 4220 {lab=trim[25]}
N 250 5170 500 5170 {lab=trim[25]}
N 11290 4180 11380 4180 {lab=\\dstage[8].id.d1\\}
N 11380 4180 11380 3690 {lab=\\dstage[8].id.d1\\}
N 11380 3690 11460 3690 {lab=\\dstage[8].id.d1\\}
N 11040 3200 10940 3200 {lab=\\dstage[8].id.d1\\}
N 10940 3200 10940 3000 {lab=\\dstage[8].id.d1\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d1\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d1\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.d1\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.d1\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d1\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d1\\}
N 11060 3020 10940 3020 {lab=\\dstage[8].id.d1\\}
N 10940 3020 10940 3000 {lab=\\dstage[8].id.d1\\}
N 10940 3000 11060 3000 {lab=\\dstage[8].id.d1\\}
N 11060 3000 11060 3020 {lab=\\dstage[8].id.d1\\}
N 11060 3020 11190 3020 {lab=\\dstage[8].id.d1\\}
N 11190 3020 11190 3040 {lab=\\dstage[8].id.d1\\}
N 11190 3040 11310 3040 {lab=\\dstage[8].id.d1\\}
N 11310 3040 11310 4070 {lab=\\dstage[8].id.d1\\}
N 11310 4070 11250 3690 {lab=\\dstage[8].id.d1\\}
N 11250 3690 11460 3690 {lab=\\dstage[8].id.d1\\}
N 12040 3410 12210 3410 {lab=\\dstage[9].id.ts\\}
N 12040 3410 12210 3410 {lab=\\dstage[9].id.ts\\}
N 12040 3410 12210 3410 {lab=\\dstage[9].id.ts\\}
N 12290 3410 12190 3410 {lab=\\dstage[9].id.d0\\}
N 12190 3410 12190 3260 {lab=\\dstage[9].id.d0\\}
N 12190 3260 12310 3260 {lab=\\dstage[9].id.d0\\}
N 12310 3260 12310 3280 {lab=\\dstage[9].id.d0\\}
N 12310 3280 12190 3280 {lab=\\dstage[9].id.d0\\}
N 12190 3280 12190 3260 {lab=\\dstage[9].id.d0\\}
N 12190 3260 12310 3260 {lab=\\dstage[9].id.d0\\}
N 12310 3260 12310 3280 {lab=\\dstage[9].id.d0\\}
N 12310 3280 12380 3280 {lab=\\dstage[9].id.d0\\}
N 12380 3280 12380 4420 {lab=\\dstage[9].id.d0\\}
N 12380 4420 12460 4420 {lab=\\dstage[9].id.d0\\}
N 12790 3920 12880 3920 {lab=\\dstage[9].id.d2\\}
N 12880 3920 12880 3870 {lab=\\dstage[9].id.d2\\}
N 12880 3870 12960 3870 {lab=\\dstage[9].id.d2\\}
N 250 3830 6600 3830 {lab=trim[9]}
N 6600 3830 6600 3910 {lab=trim[9]}
N 6600 3910 12960 3910 {lab=trim[9]}
N 250 3830 500 3830 {lab=trim[9]}
N 250 5430 6360 5430 {lab=trim[26]}
N 6360 5430 6360 4460 {lab=trim[26]}
N 6360 4460 12460 4460 {lab=trim[26]}
N 250 5430 500 5430 {lab=trim[26]}
N 12540 4420 12620 4420 {lab=\\dstage[9].id.d1\\}
N 12620 4420 12620 3920 {lab=\\dstage[9].id.d1\\}
N 12620 3920 12710 3920 {lab=\\dstage[9].id.d1\\}
N 12290 3410 12190 3410 {lab=\\dstage[9].id.d1\\}
N 12190 3410 12190 3260 {lab=\\dstage[9].id.d1\\}
N 12190 3260 12310 3260 {lab=\\dstage[9].id.d1\\}
N 12310 3260 12310 3280 {lab=\\dstage[9].id.d1\\}
N 12310 3280 12190 3280 {lab=\\dstage[9].id.d1\\}
N 12190 3280 12190 3260 {lab=\\dstage[9].id.d1\\}
N 12190 3260 12310 3260 {lab=\\dstage[9].id.d1\\}
N 12310 3260 12310 3280 {lab=\\dstage[9].id.d1\\}
N 12310 3280 12500 3280 {lab=\\dstage[9].id.d1\\}
N 12500 3280 12500 3920 {lab=\\dstage[9].id.d1\\}
N 12500 3920 12710 3920 {lab=\\dstage[9].id.d1\\}
N 21790 3920 21960 3920 {lab=c[0]}
N 10790 3200 10960 3200 {lab=c[1]}
N 280 500 370 500 {lab=\\iss.one\\}
N 370 500 370 1680 {lab=\\iss.one\\}
N 370 1680 460 1680 {lab=\\iss.one\\}
N 250 2860 340 2860 {lab=reset}
N 340 2860 340 3780 {lab=reset}
N 340 3780 440 3780 {lab=reset}
N 250 2860 360 2860 {lab=reset}
N 360 2860 360 1720 {lab=reset}
N 360 1720 460 1720 {lab=reset}
N 250 2860 500 2860 {lab=reset}
N 250 4740 340 4740 {lab=trim[16]}
N 340 4740 340 3820 {lab=trim[16]}
N 340 3820 440 3820 {lab=trim[16]}
N 250 4740 10860 4740 {lab=trim[16]}
N 10860 4740 10860 5070 {lab=trim[16]}
N 10860 5070 21460 5070 {lab=trim[16]}
N 250 4740 500 4740 {lab=trim[16]}
N 20790 5080 20690 5080 {lab=\\iss.d0\\}
N 20690 5080 20690 2750 {lab=\\iss.d0\\}
N 20690 2750 20810 2750 {lab=\\iss.d0\\}
N 20810 2750 20810 2770 {lab=\\iss.d0\\}
N 20810 2770 20880 2770 {lab=\\iss.d0\\}
N 20880 2770 20880 5570 {lab=\\iss.d0\\}
N 20880 5570 20960 5570 {lab=\\iss.d0\\}
N 21290 5320 21380 5320 {lab=\\iss.d2\\}
N 21380 5320 21380 5030 {lab=\\iss.d2\\}
N 21380 5030 21460 5030 {lab=\\iss.d2\\}
N 250 6050 10600 6050 {lab=trim[33]}
N 10600 6050 10600 5610 {lab=trim[33]}
N 10600 5610 20960 5610 {lab=trim[33]}
N 250 6050 500 6050 {lab=trim[33]}
N 21040 5570 21120 5570 {lab=\\iss.d1\\}
N 21120 5570 21120 5320 {lab=\\iss.d1\\}
N 21120 5320 21210 5320 {lab=\\iss.d1\\}
N 20790 5080 20690 5080 {lab=\\iss.d1\\}
N 20690 5080 20690 2750 {lab=\\iss.d1\\}
N 20690 2750 20810 2750 {lab=\\iss.d1\\}
N 20810 2750 20810 2770 {lab=\\iss.d1\\}
N 20810 2770 21000 2770 {lab=\\iss.d1\\}
N 21000 2770 21000 5320 {lab=\\iss.d1\\}
N 21000 5320 21210 5320 {lab=\\iss.d1\\}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 22250 3920 0 0 {name=X_1_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 11250 3200 0 0 {name=X_2_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 750 3810 0 0 {name=X\\dstage[0].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 1000 3810 0 0 {name=X\\dstage[0].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1750 2450 0 0 {name=X\\dstage[0].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1250 3330 0 0 {name=X\\dstage[0].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 1000 3810 0 0 {name=X\\dstage[0].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 1000 3810 0 0 {name=X\\dstage[0].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 1500 3570 0 0 {name=X\\dstage[0].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 13250 3640 0 0 {name=X\\dstage[10].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 13500 3640 0 0 {name=X\\dstage[10].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 14250 4120 0 0 {name=X\\dstage[10].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13750 4660 0 0 {name=X\\dstage[10].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 13500 3640 0 0 {name=X\\dstage[10].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 13500 3640 0 0 {name=X\\dstage[10].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 14000 4150 0 0 {name=X\\dstage[10].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 14500 3880 0 0 {name=X\\dstage[11].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 14750 3880 0 0 {name=X\\dstage[11].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15500 4370 0 0 {name=X\\dstage[11].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15000 4910 0 0 {name=X\\dstage[11].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 14750 3880 0 0 {name=X\\dstage[11].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 14750 3880 0 0 {name=X\\dstage[11].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 15250 4400 0 0 {name=X\\dstage[11].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 15750 4120 0 0 {name=X\\dstage[12].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 16000 4120 0 0 {name=X\\dstage[12].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16750 4610 0 0 {name=X\\dstage[12].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16250 5150 0 0 {name=X\\dstage[12].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 16000 4120 0 0 {name=X\\dstage[12].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 16000 4120 0 0 {name=X\\dstage[12].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 16500 4640 0 0 {name=X\\dstage[12].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 17000 4370 0 0 {name=X\\dstage[13].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 17250 4370 0 0 {name=X\\dstage[13].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 18000 4860 0 0 {name=X\\dstage[13].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 17500 5400 0 0 {name=X\\dstage[13].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 17250 4370 0 0 {name=X\\dstage[13].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 17250 4370 0 0 {name=X\\dstage[13].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 17750 4890 0 0 {name=X\\dstage[13].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 18250 4620 0 0 {name=X\\dstage[14].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 18500 4620 0 0 {name=X\\dstage[14].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 19250 5110 0 0 {name=X\\dstage[14].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 18750 5650 0 0 {name=X\\dstage[14].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 18500 4620 0 0 {name=X\\dstage[14].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 18500 4620 0 0 {name=X\\dstage[14].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 19000 5130 0 0 {name=X\\dstage[14].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 19500 4860 0 0 {name=X\\dstage[15].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 19750 4860 0 0 {name=X\\dstage[15].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 20500 5360 0 0 {name=X\\dstage[15].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 20000 5900 0 0 {name=X\\dstage[15].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 250 4800 0 0 {name=X\\dstage[15].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 19750 4860 0 0 {name=X\\dstage[15].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 20250 5380 0 0 {name=X\\dstage[15].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 2000 3130 0 0 {name=X\\dstage[1].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 2250 3130 0 0 {name=X\\dstage[1].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3000 2410 0 0 {name=X\\dstage[1].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 2500 3170 0 0 {name=X\\dstage[1].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 2250 3130 0 0 {name=X\\dstage[1].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 2250 3130 0 0 {name=X\\dstage[1].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 2750 3150 0 0 {name=X\\dstage[1].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 3250 2770 0 0 {name=X\\dstage[2].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 3500 2770 0 0 {name=X\\dstage[2].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 4250 2460 0 0 {name=X\\dstage[2].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3750 3150 0 0 {name=X\\dstage[2].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 3500 2770 0 0 {name=X\\dstage[2].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 3500 2770 0 0 {name=X\\dstage[2].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 4000 2960 0 0 {name=X\\dstage[2].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 4500 2620 0 0 {name=X\\dstage[3].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 4750 2620 0 0 {name=X\\dstage[3].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5500 2590 0 0 {name=X\\dstage[3].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5000 3220 0 0 {name=X\\dstage[3].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 4750 2620 0 0 {name=X\\dstage[3].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 4750 2620 0 0 {name=X\\dstage[3].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 5250 2920 0 0 {name=X\\dstage[3].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 5750 2600 0 0 {name=X\\dstage[4].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 6000 2600 0 0 {name=X\\dstage[4].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6750 2760 0 0 {name=X\\dstage[4].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6250 3360 0 0 {name=X\\dstage[4].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 6000 2600 0 0 {name=X\\dstage[4].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 6000 2600 0 0 {name=X\\dstage[4].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 6500 2980 0 0 {name=X\\dstage[4].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 7000 2680 0 0 {name=X\\dstage[5].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 7250 2680 0 0 {name=X\\dstage[5].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8000 2950 0 0 {name=X\\dstage[5].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 7500 3530 0 0 {name=X\\dstage[5].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 7250 2680 0 0 {name=X\\dstage[5].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 7250 2680 0 0 {name=X\\dstage[5].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 7750 3110 0 0 {name=X\\dstage[5].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 8250 2820 0 0 {name=X\\dstage[6].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 8500 2820 0 0 {name=X\\dstage[6].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 9250 3170 0 0 {name=X\\dstage[6].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8750 3740 0 0 {name=X\\dstage[6].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 8500 2820 0 0 {name=X\\dstage[6].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 8500 2820 0 0 {name=X\\dstage[6].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 9000 3280 0 0 {name=X\\dstage[6].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 9500 2990 0 0 {name=X\\dstage[7].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 9750 2990 0 0 {name=X\\dstage[7].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10500 3400 0 0 {name=X\\dstage[7].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10000 3950 0 0 {name=X\\dstage[7].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 9750 2990 0 0 {name=X\\dstage[7].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 9750 2990 0 0 {name=X\\dstage[7].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 10250 3470 0 0 {name=X\\dstage[7].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 10750 3200 0 0 {name=X\\dstage[8].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 11000 3200 0 0 {name=X\\dstage[8].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11750 3630 0 0 {name=X\\dstage[8].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11250 4180 0 0 {name=X\\dstage[8].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 11000 3200 0 0 {name=X\\dstage[8].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 11000 3200 0 0 {name=X\\dstage[8].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 11500 3690 0 0 {name=X\\dstage[8].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 12000 3410 0 0 {name=X\\dstage[9].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 12250 3410 0 0 {name=X\\dstage[9].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13000 3870 0 0 {name=X\\dstage[9].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 12500 4420 0 0 {name=X\\dstage[9].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 12250 3410 0 0 {name=X\\dstage[9].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 12250 3410 0 0 {name=X\\dstage[9].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 12750 3920 0 0 {name=X\\dstage[9].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 21750 3920 0 0 {name=Xibufp00 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 22000 3920 0 0 {name=Xibufp01 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 10750 3200 0 0 {name=Xibufp10 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 11000 3200 0 0 {name=Xibufp11 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__conb_1.sym} 250 500 0 0 {name=X\\iss.const1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__or2_2.sym} 500 3800 0 0 {name=X\\iss.ctrlen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 20750 5080 0 0 {name=X\\iss.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 21500 5030 0 0 {name=X\\iss.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 21000 5570 0 0 {name=X\\iss.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 500 5050 0 0 {name=X\\iss.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 20750 5080 0 0 {name=X\\iss.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 21250 5320 0 0 {name=X\\iss.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_1.sym} 500 1680 0 0 {name=X\\iss.reseten0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2860 0 0 {name=Xantenna_0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6050 0 0 {name=Xantenna_1[33] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6940 0 0 {name=Xantenna_1[32] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6690 0 0 {name=Xantenna_1[31] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6440 0 0 {name=Xantenna_1[30] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6190 0 0 {name=Xantenna_1[29] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5930 0 0 {name=Xantenna_1[28] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5680 0 0 {name=Xantenna_1[27] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5430 0 0 {name=Xantenna_1[26] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5170 0 0 {name=Xantenna_1[25] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4920 0 0 {name=Xantenna_1[24] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4650 0 0 {name=Xantenna_1[23] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4390 0 0 {name=Xantenna_1[22] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4110 0 0 {name=Xantenna_1[21] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3830 0 0 {name=Xantenna_1[20] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3530 0 0 {name=Xantenna_1[19] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3210 0 0 {name=Xantenna_1[18] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2850 0 0 {name=Xantenna_1[17] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4740 0 0 {name=Xantenna_1[16] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5340 0 0 {name=Xantenna_1[15] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5090 0 0 {name=Xantenna_1[14] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4840 0 0 {name=Xantenna_1[13] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4590 0 0 {name=Xantenna_1[12] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4340 0 0 {name=Xantenna_1[11] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4080 0 0 {name=Xantenna_1[10] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3830 0 0 {name=Xantenna_1[9] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3580 0 0 {name=Xantenna_1[8] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3320 0 0 {name=Xantenna_1[7] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3060 0 0 {name=Xantenna_1[6] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2800 0 0 {name=Xantenna_1[5] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2530 0 0 {name=Xantenna_1[4] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2260 0 0 {name=Xantenna_1[3] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1970 0 0 {name=Xantenna_1[2] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1670 0 0 {name=Xantenna_1[1] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1340 0 0 {name=Xantenna_1[0] VCCPIN=vcc VSSPIN=gnd}
C {devices/opin.sym} 22500 3920 0 0 {lab=clockp[0]}
C {devices/opin.sym} 11500 3200 0 0 {lab=clockp[1]}
C {devices/ipin.sym} 250 2860 0 0 {lab=reset}
C {devices/ipin.sym} 250 1340 0 0 {lab=trim[0]}
C {devices/ipin.sym} 250 1670 0 0 {lab=trim[1]}
C {devices/ipin.sym} 250 1970 0 0 {lab=trim[2]}
C {devices/ipin.sym} 250 2260 0 0 {lab=trim[3]}
C {devices/ipin.sym} 250 2530 0 0 {lab=trim[4]}
C {devices/ipin.sym} 250 2800 0 0 {lab=trim[5]}
C {devices/ipin.sym} 250 3060 0 0 {lab=trim[6]}
C {devices/ipin.sym} 250 3320 0 0 {lab=trim[7]}
C {devices/ipin.sym} 250 3580 0 0 {lab=trim[8]}
C {devices/ipin.sym} 250 3830 0 0 {lab=trim[9]}
C {devices/ipin.sym} 250 4080 0 0 {lab=trim[10]}
C {devices/ipin.sym} 250 4340 0 0 {lab=trim[11]}
C {devices/ipin.sym} 250 4590 0 0 {lab=trim[12]}
C {devices/ipin.sym} 250 4840 0 0 {lab=trim[13]}
C {devices/ipin.sym} 250 5090 0 0 {lab=trim[14]}
C {devices/ipin.sym} 250 5340 0 0 {lab=trim[15]}
C {devices/ipin.sym} 250 4740 0 0 {lab=trim[16]}
C {devices/ipin.sym} 250 2850 0 0 {lab=trim[17]}
C {devices/ipin.sym} 250 3210 0 0 {lab=trim[18]}
C {devices/ipin.sym} 250 3530 0 0 {lab=trim[19]}
C {devices/ipin.sym} 250 3830 0 0 {lab=trim[20]}
C {devices/ipin.sym} 250 4110 0 0 {lab=trim[21]}
C {devices/ipin.sym} 250 4390 0 0 {lab=trim[22]}
C {devices/ipin.sym} 250 4650 0 0 {lab=trim[23]}
C {devices/ipin.sym} 250 4920 0 0 {lab=trim[24]}
C {devices/ipin.sym} 250 5170 0 0 {lab=trim[25]}
C {devices/ipin.sym} 250 5430 0 0 {lab=trim[26]}
C {devices/ipin.sym} 250 5680 0 0 {lab=trim[27]}
C {devices/ipin.sym} 250 5930 0 0 {lab=trim[28]}
C {devices/ipin.sym} 250 6190 0 0 {lab=trim[29]}
C {devices/ipin.sym} 250 6440 0 0 {lab=trim[30]}
C {devices/ipin.sym} 250 6690 0 0 {lab=trim[31]}
C {devices/ipin.sym} 250 6940 0 0 {lab=trim[32]}
C {devices/ipin.sym} 250 6050 0 0 {lab=trim[33]}
