v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
N 17040 1530 17210 1530 {lab=_0_[0]}
N 17290 1530 17500 1530 {lab=clockp[0]}
N 8540 2300 8710 2300 {lab=_0_[1]}
N 8790 2300 9000 2300 {lab=clockp[1]}
N 16540 3720 8600 3720 {lab=\\dstage[0].id.in\\}
N 8600 3720 8600 380 {lab=\\dstage[0].id.in\\}
N 8600 380 940 380 {lab=\\dstage[0].id.in\\}
N 940 380 940 360 {lab=\\dstage[0].id.in\\}
N 940 360 1060 360 {lab=\\dstage[0].id.in\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.in\\}
N 1060 380 710 380 {lab=\\dstage[0].id.in\\}
N 540 250 640 250 {lab=\\dstage[0].id.in\\}
N 640 250 640 380 {lab=\\dstage[0].id.in\\}
N 640 380 710 380 {lab=\\dstage[0].id.in\\}
N 540 620 620 620 {lab=\\dstage[0].id.in\\}
N 620 620 620 380 {lab=\\dstage[0].id.in\\}
N 620 380 710 380 {lab=\\dstage[0].id.in\\}
N 16540 3720 16620 3720 {lab=\\dstage[0].id.in\\}
N 16620 3720 16620 1530 {lab=\\dstage[0].id.in\\}
N 16620 1530 16710 1530 {lab=\\dstage[0].id.in\\}
N 540 250 8620 250 {lab=\\dstage[0].id.in\\}
N 8620 250 8620 1530 {lab=\\dstage[0].id.in\\}
N 8620 1530 16710 1530 {lab=\\dstage[0].id.in\\}
N 540 620 8640 620 {lab=\\dstage[0].id.in\\}
N 8640 620 8640 1530 {lab=\\dstage[0].id.in\\}
N 8640 1530 16710 1530 {lab=\\dstage[0].id.in\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 1040 380 940 380 {lab=\\dstage[0].id.d0\\}
N 940 380 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d0\\}
N 940 380 940 360 {lab=\\dstage[0].id.d0\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d0\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d0\\}
N 1060 380 1120 380 {lab=\\dstage[0].id.d0\\}
N 1120 380 1120 2310 {lab=\\dstage[0].id.d0\\}
N 1120 2310 1210 2310 {lab=\\dstage[0].id.d0\\}
N 1540 1340 1620 1340 {lab=\\dstage[0].id.d2\\}
N 1620 1340 1620 1170 {lab=\\dstage[0].id.d2\\}
N 1620 1170 1710 1170 {lab=\\dstage[0].id.d2\\}
N 250 1210 1710 1210 {lab=trim[0]}
N 1790 1170 1880 1170 {lab=\\dstage[0].id.out\\}
N 1880 1170 1880 770 {lab=\\dstage[0].id.out\\}
N 1880 770 1960 770 {lab=\\dstage[0].id.out\\}
N 1040 380 940 380 {lab=\\dstage[0].id.out\\}
N 940 380 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 940 380 {lab=\\dstage[0].id.out\\}
N 940 380 940 360 {lab=\\dstage[0].id.out\\}
N 940 360 1060 360 {lab=\\dstage[0].id.out\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.out\\}
N 1060 380 1500 380 {lab=\\dstage[0].id.out\\}
N 1500 380 1500 770 {lab=\\dstage[0].id.out\\}
N 1500 770 1960 770 {lab=\\dstage[0].id.out\\}
N 250 2350 1210 2350 {lab=trim[13]}
N 1290 2310 1380 2310 {lab=\\dstage[0].id.d1\\}
N 1380 2310 1380 1340 {lab=\\dstage[0].id.d1\\}
N 1380 1340 1460 1340 {lab=\\dstage[0].id.d1\\}
N 1040 380 940 380 {lab=\\dstage[0].id.d1\\}
N 940 380 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 940 380 {lab=\\dstage[0].id.d1\\}
N 940 380 940 360 {lab=\\dstage[0].id.d1\\}
N 940 360 1060 360 {lab=\\dstage[0].id.d1\\}
N 1060 360 1060 380 {lab=\\dstage[0].id.d1\\}
N 1060 380 1250 380 {lab=\\dstage[0].id.d1\\}
N 1250 380 1250 1340 {lab=\\dstage[0].id.d1\\}
N 1250 1340 1460 1340 {lab=\\dstage[0].id.d1\\}
N 13040 3590 13120 3590 {lab=\\dstage[10].id.in\\}
N 13120 3590 13120 3340 {lab=\\dstage[10].id.in\\}
N 13120 3340 13210 3340 {lab=\\dstage[10].id.in\\}
N 12290 3080 12190 3080 {lab=\\dstage[10].id.in\\}
N 12190 3080 12190 3060 {lab=\\dstage[10].id.in\\}
N 12190 3060 12310 3060 {lab=\\dstage[10].id.in\\}
N 12310 3060 12310 3080 {lab=\\dstage[10].id.in\\}
N 12310 3080 12190 3080 {lab=\\dstage[10].id.in\\}
N 12190 3080 12190 3060 {lab=\\dstage[10].id.in\\}
N 12190 3060 12310 3060 {lab=\\dstage[10].id.in\\}
N 12310 3060 12310 3080 {lab=\\dstage[10].id.in\\}
N 12310 3080 12750 3080 {lab=\\dstage[10].id.in\\}
N 12750 3080 12750 3340 {lab=\\dstage[10].id.in\\}
N 12750 3340 13210 3340 {lab=\\dstage[10].id.in\\}
N 13290 3340 13460 3340 {lab=\\dstage[10].id.ts\\}
N 13290 3340 13460 3340 {lab=\\dstage[10].id.ts\\}
N 13290 3340 13460 3340 {lab=\\dstage[10].id.ts\\}
N 13540 3340 13440 3340 {lab=\\dstage[10].id.d0\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d0\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d0\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d0\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.d0\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d0\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d0\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d0\\}
N 13560 3340 13620 3340 {lab=\\dstage[10].id.d0\\}
N 13620 3340 13620 5040 {lab=\\dstage[10].id.d0\\}
N 13620 5040 13710 5040 {lab=\\dstage[10].id.d0\\}
N 14040 4190 14120 4190 {lab=\\dstage[10].id.d2\\}
N 14120 4190 14120 3850 {lab=\\dstage[10].id.d2\\}
N 14120 3850 14210 3850 {lab=\\dstage[10].id.d2\\}
N 250 3890 14210 3890 {lab=trim[10]}
N 14290 3850 14380 3850 {lab=\\dstage[10].id.out\\}
N 14380 3850 14380 3590 {lab=\\dstage[10].id.out\\}
N 14380 3590 14460 3590 {lab=\\dstage[10].id.out\\}
N 13540 3340 13440 3340 {lab=\\dstage[10].id.out\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.out\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.out\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.out\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.out\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.out\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.out\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.out\\}
N 13560 3340 14000 3340 {lab=\\dstage[10].id.out\\}
N 14000 3340 14000 3590 {lab=\\dstage[10].id.out\\}
N 14000 3590 14460 3590 {lab=\\dstage[10].id.out\\}
N 250 5080 13710 5080 {lab=trim[23]}
N 13790 5040 13880 5040 {lab=\\dstage[10].id.d1\\}
N 13880 5040 13880 4190 {lab=\\dstage[10].id.d1\\}
N 13880 4190 13960 4190 {lab=\\dstage[10].id.d1\\}
N 13540 3340 13440 3340 {lab=\\dstage[10].id.d1\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d1\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d1\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d1\\}
N 13560 3340 13440 3340 {lab=\\dstage[10].id.d1\\}
N 13440 3340 13440 3320 {lab=\\dstage[10].id.d1\\}
N 13440 3320 13560 3320 {lab=\\dstage[10].id.d1\\}
N 13560 3320 13560 3340 {lab=\\dstage[10].id.d1\\}
N 13560 3340 13750 3340 {lab=\\dstage[10].id.d1\\}
N 13750 3340 13750 4190 {lab=\\dstage[10].id.d1\\}
N 13750 4190 13960 4190 {lab=\\dstage[10].id.d1\\}
N 14540 3590 14710 3590 {lab=\\dstage[11].id.ts\\}
N 14540 3590 7360 3590 {lab=\\dstage[11].id.ts\\}
N 7360 3590 7360 250 {lab=\\dstage[11].id.ts\\}
N 7360 250 440 250 {lab=\\dstage[11].id.ts\\}
N 440 250 440 230 {lab=\\dstage[11].id.ts\\}
N 440 230 560 230 {lab=\\dstage[11].id.ts\\}
N 560 230 560 250 {lab=\\dstage[11].id.ts\\}
N 560 250 210 250 {lab=\\dstage[11].id.ts\\}
N 14540 3590 14710 3590 {lab=\\dstage[11].id.ts\\}
N 14790 3590 14690 3590 {lab=\\dstage[11].id.d0\\}
N 14690 3590 14690 3570 {lab=\\dstage[11].id.d0\\}
N 14690 3570 14810 3570 {lab=\\dstage[11].id.d0\\}
N 14810 3570 14810 3590 {lab=\\dstage[11].id.d0\\}
N 14810 3590 14880 3590 {lab=\\dstage[11].id.d0\\}
N 14880 3590 14880 5300 {lab=\\dstage[11].id.d0\\}
N 14880 5300 14960 5300 {lab=\\dstage[11].id.d0\\}
N 15290 4440 15380 4440 {lab=\\dstage[11].id.d2\\}
N 15380 4440 15380 4100 {lab=\\dstage[11].id.d2\\}
N 15380 4100 15460 4100 {lab=\\dstage[11].id.d2\\}
N 250 4140 15460 4140 {lab=trim[11]}
N 15540 4100 15640 4100 {lab=\\dstage[11].id.out\\}
N 15640 4100 15640 2170 {lab=\\dstage[11].id.out\\}
N 15640 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 2170 {lab=\\dstage[11].id.out\\}
N 15810 2170 15710 2170 {lab=\\dstage[11].id.out\\}
N 15540 4100 7980 4100 {lab=\\dstage[11].id.out\\}
N 7980 4100 7940 4100 {lab=\\dstage[11].id.out\\}
N 7940 4100 7940 2550 {lab=\\dstage[11].id.out\\}
N 7940 2550 8060 2550 {lab=\\dstage[11].id.out\\}
N 8060 2550 8060 250 {lab=\\dstage[11].id.out\\}
N 8060 250 7980 250 {lab=\\dstage[11].id.out\\}
N 7980 250 460 250 {lab=\\dstage[11].id.out\\}
N 15540 4100 15620 4100 {lab=\\dstage[11].id.out\\}
N 15620 4100 15620 2170 {lab=\\dstage[11].id.out\\}
N 15620 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 2170 {lab=\\dstage[11].id.out\\}
N 15810 2170 15710 2170 {lab=\\dstage[11].id.out\\}
N 290 250 440 250 {lab=\\dstage[11].id.out\\}
N 440 250 440 230 {lab=\\dstage[11].id.out\\}
N 440 230 560 230 {lab=\\dstage[11].id.out\\}
N 560 230 560 250 {lab=\\dstage[11].id.out\\}
N 560 250 8020 250 {lab=\\dstage[11].id.out\\}
N 8020 250 8020 2170 {lab=\\dstage[11].id.out\\}
N 8020 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 2170 {lab=\\dstage[11].id.out\\}
N 15810 2170 15710 2170 {lab=\\dstage[11].id.out\\}
N 290 250 460 250 {lab=\\dstage[11].id.out\\}
N 290 250 440 250 {lab=\\dstage[11].id.out\\}
N 440 250 440 230 {lab=\\dstage[11].id.out\\}
N 440 230 560 230 {lab=\\dstage[11].id.out\\}
N 560 230 560 250 {lab=\\dstage[11].id.out\\}
N 560 250 8000 250 {lab=\\dstage[11].id.out\\}
N 8000 250 8000 2170 {lab=\\dstage[11].id.out\\}
N 8000 2170 15690 2170 {lab=\\dstage[11].id.out\\}
N 15690 2170 15690 2150 {lab=\\dstage[11].id.out\\}
N 15690 2150 15810 2150 {lab=\\dstage[11].id.out\\}
N 15810 2150 15810 2170 {lab=\\dstage[11].id.out\\}
N 15810 2170 15710 2170 {lab=\\dstage[11].id.out\\}
N 250 5340 14960 5340 {lab=trim[24]}
N 15040 5300 15120 5300 {lab=\\dstage[11].id.d1\\}
N 15120 5300 15120 4440 {lab=\\dstage[11].id.d1\\}
N 15120 4440 15210 4440 {lab=\\dstage[11].id.d1\\}
N 14790 3590 14690 3590 {lab=\\dstage[11].id.d1\\}
N 14690 3590 14690 3570 {lab=\\dstage[11].id.d1\\}
N 14690 3570 14810 3570 {lab=\\dstage[11].id.d1\\}
N 14810 3570 14810 3590 {lab=\\dstage[11].id.d1\\}
N 14810 3590 15000 3590 {lab=\\dstage[11].id.d1\\}
N 15000 3590 15000 4440 {lab=\\dstage[11].id.d1\\}
N 15000 4440 15210 4440 {lab=\\dstage[11].id.d1\\}
N 2040 770 2210 770 {lab=\\dstage[1].id.ts\\}
N 2040 770 2210 770 {lab=\\dstage[1].id.ts\\}
N 2040 770 2210 770 {lab=\\dstage[1].id.ts\\}
N 2290 770 2190 770 {lab=\\dstage[1].id.d0\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d0\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d0\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d0\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.d0\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d0\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d0\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d0\\}
N 2310 770 2380 770 {lab=\\dstage[1].id.d0\\}
N 2380 770 2380 2640 {lab=\\dstage[1].id.d0\\}
N 2380 2640 2460 2640 {lab=\\dstage[1].id.d0\\}
N 2790 1710 2880 1710 {lab=\\dstage[1].id.d2\\}
N 2880 1710 2880 1480 {lab=\\dstage[1].id.d2\\}
N 2880 1480 2960 1480 {lab=\\dstage[1].id.d2\\}
N 250 1520 2960 1520 {lab=trim[1]}
N 3040 1480 3120 1480 {lab=\\dstage[1].id.out\\}
N 3120 1480 3120 1130 {lab=\\dstage[1].id.out\\}
N 3120 1130 3210 1130 {lab=\\dstage[1].id.out\\}
N 2290 770 2190 770 {lab=\\dstage[1].id.out\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.out\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.out\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.out\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.out\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.out\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.out\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.out\\}
N 2310 770 2750 770 {lab=\\dstage[1].id.out\\}
N 2750 770 2750 1130 {lab=\\dstage[1].id.out\\}
N 2750 1130 3210 1130 {lab=\\dstage[1].id.out\\}
N 250 2680 2460 2680 {lab=trim[14]}
N 2540 2640 2620 2640 {lab=\\dstage[1].id.d1\\}
N 2620 2640 2620 1710 {lab=\\dstage[1].id.d1\\}
N 2620 1710 2710 1710 {lab=\\dstage[1].id.d1\\}
N 2290 770 2190 770 {lab=\\dstage[1].id.d1\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d1\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d1\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d1\\}
N 2310 770 2190 770 {lab=\\dstage[1].id.d1\\}
N 2190 770 2190 750 {lab=\\dstage[1].id.d1\\}
N 2190 750 2310 750 {lab=\\dstage[1].id.d1\\}
N 2310 750 2310 770 {lab=\\dstage[1].id.d1\\}
N 2310 770 2500 770 {lab=\\dstage[1].id.d1\\}
N 2500 770 2500 1710 {lab=\\dstage[1].id.d1\\}
N 2500 1710 2710 1710 {lab=\\dstage[1].id.d1\\}
N 3290 1130 3460 1130 {lab=\\dstage[2].id.ts\\}
N 3290 1130 3460 1130 {lab=\\dstage[2].id.ts\\}
N 3290 1130 3460 1130 {lab=\\dstage[2].id.ts\\}
N 3540 1130 3440 1130 {lab=\\dstage[2].id.d0\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d0\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d0\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d0\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.d0\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d0\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d0\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d0\\}
N 3560 1130 3620 1130 {lab=\\dstage[2].id.d0\\}
N 3620 1130 3620 2940 {lab=\\dstage[2].id.d0\\}
N 3620 2940 3710 2940 {lab=\\dstage[2].id.d0\\}
N 4040 2030 4120 2030 {lab=\\dstage[2].id.d2\\}
N 4120 2030 4120 1770 {lab=\\dstage[2].id.d2\\}
N 4120 1770 4210 1770 {lab=\\dstage[2].id.d2\\}
N 250 1810 4210 1810 {lab=trim[2]}
N 4290 1770 4380 1770 {lab=\\dstage[2].id.out\\}
N 4380 1770 4380 1450 {lab=\\dstage[2].id.out\\}
N 4380 1450 4460 1450 {lab=\\dstage[2].id.out\\}
N 3540 1130 3440 1130 {lab=\\dstage[2].id.out\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.out\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.out\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.out\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.out\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.out\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.out\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.out\\}
N 3560 1130 4000 1130 {lab=\\dstage[2].id.out\\}
N 4000 1130 4000 1450 {lab=\\dstage[2].id.out\\}
N 4000 1450 4460 1450 {lab=\\dstage[2].id.out\\}
N 250 2980 3710 2980 {lab=trim[15]}
N 3790 2940 3880 2940 {lab=\\dstage[2].id.d1\\}
N 3880 2940 3880 2030 {lab=\\dstage[2].id.d1\\}
N 3880 2030 3960 2030 {lab=\\dstage[2].id.d1\\}
N 3540 1130 3440 1130 {lab=\\dstage[2].id.d1\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d1\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d1\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d1\\}
N 3560 1130 3440 1130 {lab=\\dstage[2].id.d1\\}
N 3440 1130 3440 1110 {lab=\\dstage[2].id.d1\\}
N 3440 1110 3560 1110 {lab=\\dstage[2].id.d1\\}
N 3560 1110 3560 1130 {lab=\\dstage[2].id.d1\\}
N 3560 1130 3750 1130 {lab=\\dstage[2].id.d1\\}
N 3750 1130 3750 2030 {lab=\\dstage[2].id.d1\\}
N 3750 2030 3960 2030 {lab=\\dstage[2].id.d1\\}
N 4540 1450 4710 1450 {lab=\\dstage[3].id.ts\\}
N 4540 1450 4710 1450 {lab=\\dstage[3].id.ts\\}
N 4540 1450 4710 1450 {lab=\\dstage[3].id.ts\\}
N 4790 1450 4690 1450 {lab=\\dstage[3].id.d0\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d0\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d0\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d0\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.d0\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d0\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d0\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d0\\}
N 4810 1450 4880 1450 {lab=\\dstage[3].id.d0\\}
N 4880 1450 4880 3220 {lab=\\dstage[3].id.d0\\}
N 4880 3220 4960 3220 {lab=\\dstage[3].id.d0\\}
N 5290 2330 5380 2330 {lab=\\dstage[3].id.d2\\}
N 5380 2330 5380 2040 {lab=\\dstage[3].id.d2\\}
N 5380 2040 5460 2040 {lab=\\dstage[3].id.d2\\}
N 250 2080 5460 2080 {lab=trim[3]}
N 5540 2040 5620 2040 {lab=\\dstage[3].id.out\\}
N 5620 2040 5620 1740 {lab=\\dstage[3].id.out\\}
N 5620 1740 5710 1740 {lab=\\dstage[3].id.out\\}
N 4790 1450 4690 1450 {lab=\\dstage[3].id.out\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.out\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.out\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.out\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.out\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.out\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.out\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.out\\}
N 4810 1450 5250 1450 {lab=\\dstage[3].id.out\\}
N 5250 1450 5250 1740 {lab=\\dstage[3].id.out\\}
N 5250 1740 5710 1740 {lab=\\dstage[3].id.out\\}
N 250 3260 4960 3260 {lab=trim[16]}
N 5040 3220 5120 3220 {lab=\\dstage[3].id.d1\\}
N 5120 3220 5120 2330 {lab=\\dstage[3].id.d1\\}
N 5120 2330 5210 2330 {lab=\\dstage[3].id.d1\\}
N 4790 1450 4690 1450 {lab=\\dstage[3].id.d1\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d1\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d1\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d1\\}
N 4810 1450 4690 1450 {lab=\\dstage[3].id.d1\\}
N 4690 1450 4690 1430 {lab=\\dstage[3].id.d1\\}
N 4690 1430 4810 1430 {lab=\\dstage[3].id.d1\\}
N 4810 1430 4810 1450 {lab=\\dstage[3].id.d1\\}
N 4810 1450 5000 1450 {lab=\\dstage[3].id.d1\\}
N 5000 1450 5000 2330 {lab=\\dstage[3].id.d1\\}
N 5000 2330 5210 2330 {lab=\\dstage[3].id.d1\\}
N 5790 1740 5960 1740 {lab=\\dstage[4].id.ts\\}
N 5790 1740 5960 1740 {lab=\\dstage[4].id.ts\\}
N 5790 1740 5960 1740 {lab=\\dstage[4].id.ts\\}
N 6040 1740 5940 1740 {lab=\\dstage[4].id.d0\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d0\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d0\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d0\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.d0\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d0\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d0\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d0\\}
N 6060 1740 6120 1740 {lab=\\dstage[4].id.d0\\}
N 6120 1740 6120 3500 {lab=\\dstage[4].id.d0\\}
N 6120 3500 6210 3500 {lab=\\dstage[4].id.d0\\}
N 6540 2620 6620 2620 {lab=\\dstage[4].id.d2\\}
N 6620 2620 6620 2310 {lab=\\dstage[4].id.d2\\}
N 6620 2310 6710 2310 {lab=\\dstage[4].id.d2\\}
N 250 2350 6710 2350 {lab=trim[4]}
N 6790 2310 6880 2310 {lab=\\dstage[4].id.out\\}
N 6880 2310 6880 2030 {lab=\\dstage[4].id.out\\}
N 6880 2030 6960 2030 {lab=\\dstage[4].id.out\\}
N 6040 1740 5940 1740 {lab=\\dstage[4].id.out\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.out\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.out\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.out\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.out\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.out\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.out\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.out\\}
N 6060 1740 6500 1740 {lab=\\dstage[4].id.out\\}
N 6500 1740 6500 2030 {lab=\\dstage[4].id.out\\}
N 6500 2030 6960 2030 {lab=\\dstage[4].id.out\\}
N 250 3540 6210 3540 {lab=trim[17]}
N 6290 3500 6380 3500 {lab=\\dstage[4].id.d1\\}
N 6380 3500 6380 2620 {lab=\\dstage[4].id.d1\\}
N 6380 2620 6460 2620 {lab=\\dstage[4].id.d1\\}
N 6040 1740 5940 1740 {lab=\\dstage[4].id.d1\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d1\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d1\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d1\\}
N 6060 1740 5940 1740 {lab=\\dstage[4].id.d1\\}
N 5940 1740 5940 1720 {lab=\\dstage[4].id.d1\\}
N 5940 1720 6060 1720 {lab=\\dstage[4].id.d1\\}
N 6060 1720 6060 1740 {lab=\\dstage[4].id.d1\\}
N 6060 1740 6250 1740 {lab=\\dstage[4].id.d1\\}
N 6250 1740 6250 2620 {lab=\\dstage[4].id.d1\\}
N 6250 2620 6460 2620 {lab=\\dstage[4].id.d1\\}
N 7040 2030 7210 2030 {lab=\\dstage[5].id.ts\\}
N 7040 2030 7210 2030 {lab=\\dstage[5].id.ts\\}
N 7040 2030 7210 2030 {lab=\\dstage[5].id.ts\\}
N 7290 2030 7190 2030 {lab=\\dstage[5].id.d0\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d0\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d0\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d0\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.d0\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d0\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d0\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d0\\}
N 7310 2030 7380 2030 {lab=\\dstage[5].id.d0\\}
N 7380 2030 7380 3760 {lab=\\dstage[5].id.d0\\}
N 7380 3760 7460 3760 {lab=\\dstage[5].id.d0\\}
N 7790 2900 7880 2900 {lab=\\dstage[5].id.d2\\}
N 7880 2900 7880 2570 {lab=\\dstage[5].id.d2\\}
N 7880 2570 7960 2570 {lab=\\dstage[5].id.d2\\}
N 250 2610 7960 2610 {lab=trim[5]}
N 8040 2570 8140 2570 {lab=\\dstage[5].id.out\\}
N 8140 2570 8140 2300 {lab=\\dstage[5].id.out\\}
N 8140 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2300 {lab=\\dstage[5].id.out\\}
N 8310 2300 8210 2300 {lab=\\dstage[5].id.out\\}
N 8040 2570 8120 2570 {lab=\\dstage[5].id.out\\}
N 8120 2570 8120 2300 {lab=\\dstage[5].id.out\\}
N 8120 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2300 {lab=\\dstage[5].id.out\\}
N 8310 2300 8210 2300 {lab=\\dstage[5].id.out\\}
N 7290 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7760 2030 {lab=\\dstage[5].id.out\\}
N 7760 2030 7760 2300 {lab=\\dstage[5].id.out\\}
N 7760 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2300 {lab=\\dstage[5].id.out\\}
N 8310 2300 8210 2300 {lab=\\dstage[5].id.out\\}
N 7290 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.out\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.out\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.out\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.out\\}
N 7310 2030 7740 2030 {lab=\\dstage[5].id.out\\}
N 7740 2030 7740 2300 {lab=\\dstage[5].id.out\\}
N 7740 2300 8190 2300 {lab=\\dstage[5].id.out\\}
N 8190 2300 8190 2280 {lab=\\dstage[5].id.out\\}
N 8190 2280 8310 2280 {lab=\\dstage[5].id.out\\}
N 8310 2280 8310 2300 {lab=\\dstage[5].id.out\\}
N 8310 2300 8210 2300 {lab=\\dstage[5].id.out\\}
N 250 3800 7460 3800 {lab=trim[18]}
N 7540 3760 7620 3760 {lab=\\dstage[5].id.d1\\}
N 7620 3760 7620 2900 {lab=\\dstage[5].id.d1\\}
N 7620 2900 7710 2900 {lab=\\dstage[5].id.d1\\}
N 7290 2030 7190 2030 {lab=\\dstage[5].id.d1\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d1\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d1\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d1\\}
N 7310 2030 7190 2030 {lab=\\dstage[5].id.d1\\}
N 7190 2030 7190 2010 {lab=\\dstage[5].id.d1\\}
N 7190 2010 7310 2010 {lab=\\dstage[5].id.d1\\}
N 7310 2010 7310 2030 {lab=\\dstage[5].id.d1\\}
N 7310 2030 7500 2030 {lab=\\dstage[5].id.d1\\}
N 7500 2030 7500 2900 {lab=\\dstage[5].id.d1\\}
N 7500 2900 7710 2900 {lab=\\dstage[5].id.d1\\}
N 8290 2300 8460 2300 {lab=\\dstage[6].id.ts\\}
N 8290 2300 8460 2300 {lab=\\dstage[6].id.ts\\}
N 8290 2300 8460 2300 {lab=\\dstage[6].id.ts\\}
N 8540 2300 8440 2300 {lab=\\dstage[6].id.d0\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d0\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d0\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d0\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d0\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d0\\}
N 8560 2300 8640 2300 {lab=\\dstage[6].id.d0\\}
N 8640 2300 8640 4020 {lab=\\dstage[6].id.d0\\}
N 8640 4020 8710 4020 {lab=\\dstage[6].id.d0\\}
N 9040 3160 9120 3160 {lab=\\dstage[6].id.d2\\}
N 9120 3160 9120 2830 {lab=\\dstage[6].id.d2\\}
N 9120 2830 9210 2830 {lab=\\dstage[6].id.d2\\}
N 250 2870 9210 2870 {lab=trim[6]}
N 9290 2830 9380 2830 {lab=\\dstage[6].id.out\\}
N 9380 2830 9380 2570 {lab=\\dstage[6].id.out\\}
N 9380 2570 9460 2570 {lab=\\dstage[6].id.out\\}
N 8540 2300 8440 2300 {lab=\\dstage[6].id.out\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.out\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.out\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.out\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.out\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.out\\}
N 8560 2300 8690 2300 {lab=\\dstage[6].id.out\\}
N 8690 2300 8690 2280 {lab=\\dstage[6].id.out\\}
N 8690 2280 8810 2280 {lab=\\dstage[6].id.out\\}
N 8810 2280 8810 2300 {lab=\\dstage[6].id.out\\}
N 8810 2300 8980 2300 {lab=\\dstage[6].id.out\\}
N 8980 2300 8980 2320 {lab=\\dstage[6].id.out\\}
N 8980 2320 9020 2320 {lab=\\dstage[6].id.out\\}
N 9020 2320 9020 2570 {lab=\\dstage[6].id.out\\}
N 9020 2570 9000 2570 {lab=\\dstage[6].id.out\\}
N 9000 2570 9460 2570 {lab=\\dstage[6].id.out\\}
N 250 4060 8710 4060 {lab=trim[19]}
N 8790 4020 8880 4020 {lab=\\dstage[6].id.d1\\}
N 8880 4020 8880 3160 {lab=\\dstage[6].id.d1\\}
N 8880 3160 8960 3160 {lab=\\dstage[6].id.d1\\}
N 8540 2300 8440 2300 {lab=\\dstage[6].id.d1\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d1\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8440 2300 {lab=\\dstage[6].id.d1\\}
N 8440 2300 8440 2280 {lab=\\dstage[6].id.d1\\}
N 8440 2280 8560 2280 {lab=\\dstage[6].id.d1\\}
N 8560 2280 8560 2300 {lab=\\dstage[6].id.d1\\}
N 8560 2300 8690 2300 {lab=\\dstage[6].id.d1\\}
N 8690 2300 8690 2320 {lab=\\dstage[6].id.d1\\}
N 8690 2320 8810 2320 {lab=\\dstage[6].id.d1\\}
N 8810 2320 8810 3160 {lab=\\dstage[6].id.d1\\}
N 8810 3160 8750 3160 {lab=\\dstage[6].id.d1\\}
N 8750 3160 8960 3160 {lab=\\dstage[6].id.d1\\}
N 9540 2570 9710 2570 {lab=\\dstage[7].id.ts\\}
N 9540 2570 9710 2570 {lab=\\dstage[7].id.ts\\}
N 9540 2570 9710 2570 {lab=\\dstage[7].id.ts\\}
N 9790 2570 9690 2570 {lab=\\dstage[7].id.d0\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d0\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d0\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d0\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.d0\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d0\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d0\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d0\\}
N 9810 2570 9880 2570 {lab=\\dstage[7].id.d0\\}
N 9880 2570 9880 4280 {lab=\\dstage[7].id.d0\\}
N 9880 4280 9960 4280 {lab=\\dstage[7].id.d0\\}
N 10290 3420 10380 3420 {lab=\\dstage[7].id.d2\\}
N 10380 3420 10380 3090 {lab=\\dstage[7].id.d2\\}
N 10380 3090 10460 3090 {lab=\\dstage[7].id.d2\\}
N 250 3130 10460 3130 {lab=trim[7]}
N 10540 3090 10620 3090 {lab=\\dstage[7].id.out\\}
N 10620 3090 10620 2830 {lab=\\dstage[7].id.out\\}
N 10620 2830 10710 2830 {lab=\\dstage[7].id.out\\}
N 9790 2570 9690 2570 {lab=\\dstage[7].id.out\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.out\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.out\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.out\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.out\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.out\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.out\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.out\\}
N 9810 2570 10250 2570 {lab=\\dstage[7].id.out\\}
N 10250 2570 10250 2830 {lab=\\dstage[7].id.out\\}
N 10250 2830 10710 2830 {lab=\\dstage[7].id.out\\}
N 250 4320 9960 4320 {lab=trim[20]}
N 10040 4280 10120 4280 {lab=\\dstage[7].id.d1\\}
N 10120 4280 10120 3420 {lab=\\dstage[7].id.d1\\}
N 10120 3420 10210 3420 {lab=\\dstage[7].id.d1\\}
N 9790 2570 9690 2570 {lab=\\dstage[7].id.d1\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d1\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d1\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d1\\}
N 9810 2570 9690 2570 {lab=\\dstage[7].id.d1\\}
N 9690 2570 9690 2550 {lab=\\dstage[7].id.d1\\}
N 9690 2550 9810 2550 {lab=\\dstage[7].id.d1\\}
N 9810 2550 9810 2570 {lab=\\dstage[7].id.d1\\}
N 9810 2570 10000 2570 {lab=\\dstage[7].id.d1\\}
N 10000 2570 10000 3420 {lab=\\dstage[7].id.d1\\}
N 10000 3420 10210 3420 {lab=\\dstage[7].id.d1\\}
N 10790 2830 10960 2830 {lab=\\dstage[8].id.ts\\}
N 10790 2830 10960 2830 {lab=\\dstage[8].id.ts\\}
N 10790 2830 10960 2830 {lab=\\dstage[8].id.ts\\}
N 11040 2830 10940 2830 {lab=\\dstage[8].id.d0\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d0\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d0\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d0\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.d0\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d0\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d0\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d0\\}
N 11060 2830 11120 2830 {lab=\\dstage[8].id.d0\\}
N 11120 2830 11120 4540 {lab=\\dstage[8].id.d0\\}
N 11120 4540 11210 4540 {lab=\\dstage[8].id.d0\\}
N 11540 3680 11620 3680 {lab=\\dstage[8].id.d2\\}
N 11620 3680 11620 3340 {lab=\\dstage[8].id.d2\\}
N 11620 3340 11710 3340 {lab=\\dstage[8].id.d2\\}
N 250 3380 11710 3380 {lab=trim[8]}
N 11790 3340 11880 3340 {lab=\\dstage[8].id.out\\}
N 11880 3340 11880 3080 {lab=\\dstage[8].id.out\\}
N 11880 3080 11960 3080 {lab=\\dstage[8].id.out\\}
N 11040 2830 10940 2830 {lab=\\dstage[8].id.out\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.out\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.out\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.out\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.out\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.out\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.out\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.out\\}
N 11060 2830 11500 2830 {lab=\\dstage[8].id.out\\}
N 11500 2830 11500 3080 {lab=\\dstage[8].id.out\\}
N 11500 3080 11960 3080 {lab=\\dstage[8].id.out\\}
N 250 4580 11210 4580 {lab=trim[21]}
N 11290 4540 11380 4540 {lab=\\dstage[8].id.d1\\}
N 11380 4540 11380 3680 {lab=\\dstage[8].id.d1\\}
N 11380 3680 11460 3680 {lab=\\dstage[8].id.d1\\}
N 11040 2830 10940 2830 {lab=\\dstage[8].id.d1\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d1\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d1\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d1\\}
N 11060 2830 10940 2830 {lab=\\dstage[8].id.d1\\}
N 10940 2830 10940 2810 {lab=\\dstage[8].id.d1\\}
N 10940 2810 11060 2810 {lab=\\dstage[8].id.d1\\}
N 11060 2810 11060 2830 {lab=\\dstage[8].id.d1\\}
N 11060 2830 11250 2830 {lab=\\dstage[8].id.d1\\}
N 11250 2830 11250 3680 {lab=\\dstage[8].id.d1\\}
N 11250 3680 11460 3680 {lab=\\dstage[8].id.d1\\}
N 12040 3080 12210 3080 {lab=\\dstage[9].id.ts\\}
N 12040 3080 12210 3080 {lab=\\dstage[9].id.ts\\}
N 12040 3080 12210 3080 {lab=\\dstage[9].id.ts\\}
N 12290 3080 12190 3080 {lab=\\dstage[9].id.d0\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d0\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d0\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d0\\}
N 12310 3080 12190 3080 {lab=\\dstage[9].id.d0\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d0\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d0\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d0\\}
N 12310 3080 12380 3080 {lab=\\dstage[9].id.d0\\}
N 12380 3080 12380 4790 {lab=\\dstage[9].id.d0\\}
N 12380 4790 12460 4790 {lab=\\dstage[9].id.d0\\}
N 12790 3940 12880 3940 {lab=\\dstage[9].id.d2\\}
N 12880 3940 12880 3590 {lab=\\dstage[9].id.d2\\}
N 12880 3590 12960 3590 {lab=\\dstage[9].id.d2\\}
N 250 3630 12960 3630 {lab=trim[9]}
N 250 4830 12460 4830 {lab=trim[22]}
N 12540 4790 12620 4790 {lab=\\dstage[9].id.d1\\}
N 12620 4790 12620 3940 {lab=\\dstage[9].id.d1\\}
N 12620 3940 12710 3940 {lab=\\dstage[9].id.d1\\}
N 12290 3080 12190 3080 {lab=\\dstage[9].id.d1\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d1\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d1\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d1\\}
N 12310 3080 12190 3080 {lab=\\dstage[9].id.d1\\}
N 12190 3080 12190 3060 {lab=\\dstage[9].id.d1\\}
N 12190 3060 12310 3060 {lab=\\dstage[9].id.d1\\}
N 12310 3060 12310 3080 {lab=\\dstage[9].id.d1\\}
N 12310 3080 12500 3080 {lab=\\dstage[9].id.d1\\}
N 12500 3080 12500 3940 {lab=\\dstage[9].id.d1\\}
N 12500 3940 12710 3940 {lab=\\dstage[9].id.d1\\}
N 16790 1530 16960 1530 {lab=c[0]}
N 8290 2300 8460 2300 {lab=c[1]}
N 280 500 370 500 {lab=\\iss.one\\}
N 370 500 370 620 {lab=\\iss.one\\}
N 370 620 460 620 {lab=\\iss.one\\}
N 250 2360 440 2360 {lab=reset}
N 250 2360 360 2360 {lab=reset}
N 360 2360 360 660 {lab=reset}
N 360 660 460 660 {lab=reset}
N 250 3760 340 3760 {lab=trim[12]}
N 340 3760 340 2400 {lab=trim[12]}
N 340 2400 440 2400 {lab=trim[12]}
N 250 3760 16460 3760 {lab=trim[12]}
N 15790 2170 15690 2170 {lab=\\iss.d0\\}
N 15690 2170 15690 2150 {lab=\\iss.d0\\}
N 15690 2150 15810 2150 {lab=\\iss.d0\\}
N 15810 2150 15810 2170 {lab=\\iss.d0\\}
N 15810 2170 15880 2170 {lab=\\iss.d0\\}
N 15880 2170 15880 4710 {lab=\\iss.d0\\}
N 15880 4710 15960 4710 {lab=\\iss.d0\\}
N 16290 3440 16380 3440 {lab=\\iss.d2\\}
N 16380 3440 16380 3720 {lab=\\iss.d2\\}
N 16380 3720 16460 3720 {lab=\\iss.d2\\}
N 250 4750 15960 4750 {lab=trim[25]}
N 16040 4710 16120 4710 {lab=\\iss.d1\\}
N 16120 4710 16120 3440 {lab=\\iss.d1\\}
N 16120 3440 16210 3440 {lab=\\iss.d1\\}
N 15790 2170 15690 2170 {lab=\\iss.d1\\}
N 15690 2170 15690 2150 {lab=\\iss.d1\\}
N 15690 2150 15810 2150 {lab=\\iss.d1\\}
N 15810 2150 15810 2170 {lab=\\iss.d1\\}
N 15810 2170 16000 2170 {lab=\\iss.d1\\}
N 16000 2170 16000 3440 {lab=\\iss.d1\\}
N 16000 3440 16210 3440 {lab=\\iss.d1\\}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 17250 1530 0 0 {name=X_1_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 8750 2300 0 0 {name=X_2_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 750 380 0 0 {name=X\\dstage[0].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 1000 380 0 0 {name=X\\dstage[0].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1750 1170 0 0 {name=X\\dstage[0].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1250 2310 0 0 {name=X\\dstage[0].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 1000 380 0 0 {name=X\\dstage[0].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 1000 380 0 0 {name=X\\dstage[0].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 1500 1340 0 0 {name=X\\dstage[0].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 13250 3340 0 0 {name=X\\dstage[10].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 13500 3340 0 0 {name=X\\dstage[10].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 14250 3850 0 0 {name=X\\dstage[10].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13750 5040 0 0 {name=X\\dstage[10].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 13500 3340 0 0 {name=X\\dstage[10].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 13500 3340 0 0 {name=X\\dstage[10].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 14000 4190 0 0 {name=X\\dstage[10].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 14500 3590 0 0 {name=X\\dstage[11].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 14750 3590 0 0 {name=X\\dstage[11].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15500 4100 0 0 {name=X\\dstage[11].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15000 5300 0 0 {name=X\\dstage[11].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 250 250 0 0 {name=X\\dstage[11].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 14750 3590 0 0 {name=X\\dstage[11].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 15250 4440 0 0 {name=X\\dstage[11].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 2000 770 0 0 {name=X\\dstage[1].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 2250 770 0 0 {name=X\\dstage[1].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3000 1480 0 0 {name=X\\dstage[1].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 2500 2640 0 0 {name=X\\dstage[1].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 2250 770 0 0 {name=X\\dstage[1].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 2250 770 0 0 {name=X\\dstage[1].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 2750 1710 0 0 {name=X\\dstage[1].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 3250 1130 0 0 {name=X\\dstage[2].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 3500 1130 0 0 {name=X\\dstage[2].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 4250 1770 0 0 {name=X\\dstage[2].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3750 2940 0 0 {name=X\\dstage[2].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 3500 1130 0 0 {name=X\\dstage[2].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 3500 1130 0 0 {name=X\\dstage[2].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 4000 2030 0 0 {name=X\\dstage[2].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 4500 1450 0 0 {name=X\\dstage[3].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 4750 1450 0 0 {name=X\\dstage[3].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5500 2040 0 0 {name=X\\dstage[3].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5000 3220 0 0 {name=X\\dstage[3].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 4750 1450 0 0 {name=X\\dstage[3].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 4750 1450 0 0 {name=X\\dstage[3].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 5250 2330 0 0 {name=X\\dstage[3].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 5750 1740 0 0 {name=X\\dstage[4].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 6000 1740 0 0 {name=X\\dstage[4].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6750 2310 0 0 {name=X\\dstage[4].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6250 3500 0 0 {name=X\\dstage[4].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 6000 1740 0 0 {name=X\\dstage[4].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 6000 1740 0 0 {name=X\\dstage[4].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 6500 2620 0 0 {name=X\\dstage[4].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 7000 2030 0 0 {name=X\\dstage[5].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 7250 2030 0 0 {name=X\\dstage[5].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8000 2570 0 0 {name=X\\dstage[5].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 7500 3760 0 0 {name=X\\dstage[5].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 7250 2030 0 0 {name=X\\dstage[5].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 7250 2030 0 0 {name=X\\dstage[5].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 7750 2900 0 0 {name=X\\dstage[5].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 8250 2300 0 0 {name=X\\dstage[6].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 8500 2300 0 0 {name=X\\dstage[6].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 9250 2830 0 0 {name=X\\dstage[6].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8750 4020 0 0 {name=X\\dstage[6].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 8500 2300 0 0 {name=X\\dstage[6].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 8500 2300 0 0 {name=X\\dstage[6].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 9000 3160 0 0 {name=X\\dstage[6].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 9500 2570 0 0 {name=X\\dstage[7].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 9750 2570 0 0 {name=X\\dstage[7].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10500 3090 0 0 {name=X\\dstage[7].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10000 4280 0 0 {name=X\\dstage[7].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 9750 2570 0 0 {name=X\\dstage[7].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 9750 2570 0 0 {name=X\\dstage[7].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 10250 3420 0 0 {name=X\\dstage[7].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 10750 2830 0 0 {name=X\\dstage[8].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 11000 2830 0 0 {name=X\\dstage[8].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11750 3340 0 0 {name=X\\dstage[8].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11250 4540 0 0 {name=X\\dstage[8].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 11000 2830 0 0 {name=X\\dstage[8].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 11000 2830 0 0 {name=X\\dstage[8].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 11500 3680 0 0 {name=X\\dstage[8].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 12000 3080 0 0 {name=X\\dstage[9].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 12250 3080 0 0 {name=X\\dstage[9].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13000 3590 0 0 {name=X\\dstage[9].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 12500 4790 0 0 {name=X\\dstage[9].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 12250 3080 0 0 {name=X\\dstage[9].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 12250 3080 0 0 {name=X\\dstage[9].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 12750 3940 0 0 {name=X\\dstage[9].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 16750 1530 0 0 {name=Xibufp00 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 17000 1530 0 0 {name=Xibufp01 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 8250 2300 0 0 {name=Xibufp10 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 8500 2300 0 0 {name=Xibufp11 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__conb_1.sym} 250 500 0 0 {name=X\\iss.const1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__or2_2.sym} 500 2380 0 0 {name=X\\iss.ctrlen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 15750 2170 0 0 {name=X\\iss.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16500 3720 0 0 {name=X\\iss.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16000 4710 0 0 {name=X\\iss.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 500 250 0 0 {name=X\\iss.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 15750 2170 0 0 {name=X\\iss.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 16250 3440 0 0 {name=X\\iss.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_1.sym} 500 620 0 0 {name=X\\iss.reseten0 VCCPIN=vcc VSSPIN=gnd}
C {devices/opin.sym} 17500 1530 0 0 {lab=clockp[0]}
C {devices/opin.sym} 9000 2300 0 0 {lab=clockp[1]}
C {devices/ipin.sym} 250 2360 0 0 {lab=reset}
C {devices/ipin.sym} 250 1210 0 0 {lab=trim[0]}
C {devices/ipin.sym} 250 1520 0 0 {lab=trim[1]}
C {devices/ipin.sym} 250 1810 0 0 {lab=trim[2]}
C {devices/ipin.sym} 250 2080 0 0 {lab=trim[3]}
C {devices/ipin.sym} 250 2350 0 0 {lab=trim[4]}
C {devices/ipin.sym} 250 2610 0 0 {lab=trim[5]}
C {devices/ipin.sym} 250 2870 0 0 {lab=trim[6]}
C {devices/ipin.sym} 250 3130 0 0 {lab=trim[7]}
C {devices/ipin.sym} 250 3380 0 0 {lab=trim[8]}
C {devices/ipin.sym} 250 3630 0 0 {lab=trim[9]}
C {devices/ipin.sym} 250 3890 0 0 {lab=trim[10]}
C {devices/ipin.sym} 250 4140 0 0 {lab=trim[11]}
C {devices/ipin.sym} 250 3760 0 0 {lab=trim[12]}
C {devices/ipin.sym} 250 2350 0 0 {lab=trim[13]}
C {devices/ipin.sym} 250 2680 0 0 {lab=trim[14]}
C {devices/ipin.sym} 250 2980 0 0 {lab=trim[15]}
C {devices/ipin.sym} 250 3260 0 0 {lab=trim[16]}
C {devices/ipin.sym} 250 3540 0 0 {lab=trim[17]}
C {devices/ipin.sym} 250 3800 0 0 {lab=trim[18]}
C {devices/ipin.sym} 250 4060 0 0 {lab=trim[19]}
C {devices/ipin.sym} 250 4320 0 0 {lab=trim[20]}
C {devices/ipin.sym} 250 4580 0 0 {lab=trim[21]}
C {devices/ipin.sym} 250 4830 0 0 {lab=trim[22]}
C {devices/ipin.sym} 250 5080 0 0 {lab=trim[23]}
C {devices/ipin.sym} 250 5340 0 0 {lab=trim[24]}
C {devices/ipin.sym} 250 4750 0 0 {lab=trim[25]}
