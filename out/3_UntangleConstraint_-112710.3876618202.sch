v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
N 22040 1860 22210 1860 {lab=_0_[0]}
N 22290 1860 22500 1860 {lab=clockp[0]}
N 11040 3020 11210 3020 {lab=_0_[1]}
N 11290 3020 11500 3020 {lab=clockp[1]}
N 21540 4700 11100 4700 {lab=\\dstage[0].id.in\\}
N 11100 4700 11100 380 {lab=\\dstage[0].id.in\\}
N 11100 380 710 380 {lab=\\dstage[0].id.in\\}
N 540 250 640 250 {lab=\\dstage[0].id.in\\}
N 640 250 640 380 {lab=\\dstage[0].id.in\\}
N 640 380 710 380 {lab=\\dstage[0].id.in\\}
N 540 620 620 620 {lab=\\dstage[0].id.in\\}
N 620 620 620 380 {lab=\\dstage[0].id.in\\}
N 620 380 710 380 {lab=\\dstage[0].id.in\\}
N 21540 4700 21620 4700 {lab=\\dstage[0].id.in\\}
N 21620 4700 21620 1860 {lab=\\dstage[0].id.in\\}
N 21620 1860 21710 1860 {lab=\\dstage[0].id.in\\}
N 540 250 11120 250 {lab=\\dstage[0].id.in\\}
N 11120 250 11120 1860 {lab=\\dstage[0].id.in\\}
N 11120 1860 21710 1860 {lab=\\dstage[0].id.in\\}
N 540 620 11140 620 {lab=\\dstage[0].id.in\\}
N 11140 620 11140 1860 {lab=\\dstage[0].id.in\\}
N 11140 1860 21710 1860 {lab=\\dstage[0].id.in\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 790 380 960 380 {lab=\\dstage[0].id.ts\\}
N 1040 380 1120 380 {lab=\\dstage[0].id.d0\\}
N 1120 380 1120 2810 {lab=\\dstage[0].id.d0\\}
N 1120 2810 1210 2810 {lab=\\dstage[0].id.d0\\}
N 1540 1590 1620 1590 {lab=\\dstage[0].id.d2\\}
N 1620 1590 1620 1300 {lab=\\dstage[0].id.d2\\}
N 1620 1300 1710 1300 {lab=\\dstage[0].id.d2\\}
N 250 1340 1710 1340 {lab=trim[0]}
N 250 1340 400 1340 {lab=trim[0]}
N 400 1340 400 1000 {lab=trim[0]}
N 400 1000 500 1000 {lab=trim[0]}
N 1790 1300 1880 1300 {lab=\\dstage[0].id.out\\}
N 1880 1300 1880 840 {lab=\\dstage[0].id.out\\}
N 1880 840 1960 840 {lab=\\dstage[0].id.out\\}
N 1040 380 1500 380 {lab=\\dstage[0].id.out\\}
N 1500 380 1500 840 {lab=\\dstage[0].id.out\\}
N 1500 840 1960 840 {lab=\\dstage[0].id.out\\}
N 250 2850 1210 2850 {lab=trim[17]}
N 250 2850 180 2850 {lab=trim[17]}
N 180 2850 180 5250 {lab=trim[17]}
N 180 5250 500 5250 {lab=trim[17]}
N 1290 2810 1380 2810 {lab=\\dstage[0].id.d1\\}
N 1380 2810 1380 1590 {lab=\\dstage[0].id.d1\\}
N 1380 1590 1460 1590 {lab=\\dstage[0].id.d1\\}
N 1040 380 1250 380 {lab=\\dstage[0].id.d1\\}
N 1250 380 1250 1590 {lab=\\dstage[0].id.d1\\}
N 1250 1590 1460 1590 {lab=\\dstage[0].id.d1\\}
N 13040 3790 13120 3790 {lab=\\dstage[10].id.in\\}
N 13120 3790 13120 3530 {lab=\\dstage[10].id.in\\}
N 13120 3530 13210 3530 {lab=\\dstage[10].id.in\\}
N 12290 3280 12750 3280 {lab=\\dstage[10].id.in\\}
N 12750 3280 12750 3530 {lab=\\dstage[10].id.in\\}
N 12750 3530 13210 3530 {lab=\\dstage[10].id.in\\}
N 13290 3530 13460 3530 {lab=\\dstage[10].id.ts\\}
N 13290 3530 13460 3530 {lab=\\dstage[10].id.ts\\}
N 13290 3530 13460 3530 {lab=\\dstage[10].id.ts\\}
N 13540 3530 13620 3530 {lab=\\dstage[10].id.d0\\}
N 13620 3530 13620 5640 {lab=\\dstage[10].id.d0\\}
N 13620 5640 13710 5640 {lab=\\dstage[10].id.d0\\}
N 14040 4590 14120 4590 {lab=\\dstage[10].id.d2\\}
N 14120 4590 14120 4040 {lab=\\dstage[10].id.d2\\}
N 14120 4040 14210 4040 {lab=\\dstage[10].id.d2\\}
N 250 4080 14210 4080 {lab=trim[10]}
N 250 4080 420 4080 {lab=trim[10]}
N 420 4080 420 3500 {lab=trim[10]}
N 420 3500 500 3500 {lab=trim[10]}
N 14290 4040 14380 4040 {lab=\\dstage[10].id.out\\}
N 14380 4040 14380 3790 {lab=\\dstage[10].id.out\\}
N 14380 3790 14460 3790 {lab=\\dstage[10].id.out\\}
N 13540 3530 14000 3530 {lab=\\dstage[10].id.out\\}
N 14000 3530 14000 3790 {lab=\\dstage[10].id.out\\}
N 14000 3790 14460 3790 {lab=\\dstage[10].id.out\\}
N 250 5680 13710 5680 {lab=trim[27]}
N 250 5680 420 5680 {lab=trim[27]}
N 420 5680 420 7750 {lab=trim[27]}
N 420 7750 500 7750 {lab=trim[27]}
N 13790 5640 13880 5640 {lab=\\dstage[10].id.d1\\}
N 13880 5640 13880 4590 {lab=\\dstage[10].id.d1\\}
N 13880 4590 13960 4590 {lab=\\dstage[10].id.d1\\}
N 13540 3530 13750 3530 {lab=\\dstage[10].id.d1\\}
N 13750 3530 13750 4590 {lab=\\dstage[10].id.d1\\}
N 13750 4590 13960 4590 {lab=\\dstage[10].id.d1\\}
N 14540 3790 14710 3790 {lab=\\dstage[11].id.ts\\}
N 14540 3790 14710 3790 {lab=\\dstage[11].id.ts\\}
N 14540 3790 14710 3790 {lab=\\dstage[11].id.ts\\}
N 14790 3790 14880 3790 {lab=\\dstage[11].id.d0\\}
N 14880 3790 14880 5890 {lab=\\dstage[11].id.d0\\}
N 14880 5890 14960 5890 {lab=\\dstage[11].id.d0\\}
N 15290 4840 15380 4840 {lab=\\dstage[11].id.d2\\}
N 15380 4840 15380 4300 {lab=\\dstage[11].id.d2\\}
N 15380 4300 15460 4300 {lab=\\dstage[11].id.d2\\}
N 250 4340 15460 4340 {lab=trim[11]}
N 250 4340 420 4340 {lab=trim[11]}
N 420 4340 420 3750 {lab=trim[11]}
N 420 3750 500 3750 {lab=trim[11]}
N 15540 4300 15620 4300 {lab=\\dstage[11].id.out\\}
N 15620 4300 15620 4040 {lab=\\dstage[11].id.out\\}
N 15620 4040 15710 4040 {lab=\\dstage[11].id.out\\}
N 14790 3790 15250 3790 {lab=\\dstage[11].id.out\\}
N 15250 3790 15250 4040 {lab=\\dstage[11].id.out\\}
N 15250 4040 15710 4040 {lab=\\dstage[11].id.out\\}
N 250 5930 14960 5930 {lab=trim[28]}
N 250 5930 420 5930 {lab=trim[28]}
N 420 5930 420 8000 {lab=trim[28]}
N 420 8000 500 8000 {lab=trim[28]}
N 15040 5890 15120 5890 {lab=\\dstage[11].id.d1\\}
N 15120 5890 15120 4840 {lab=\\dstage[11].id.d1\\}
N 15120 4840 15210 4840 {lab=\\dstage[11].id.d1\\}
N 14790 3790 15000 3790 {lab=\\dstage[11].id.d1\\}
N 15000 3790 15000 4840 {lab=\\dstage[11].id.d1\\}
N 15000 4840 15210 4840 {lab=\\dstage[11].id.d1\\}
N 15790 4040 15960 4040 {lab=\\dstage[12].id.ts\\}
N 15790 4040 15960 4040 {lab=\\dstage[12].id.ts\\}
N 15790 4040 15960 4040 {lab=\\dstage[12].id.ts\\}
N 16040 4040 16120 4040 {lab=\\dstage[12].id.d0\\}
N 16120 4040 16120 6150 {lab=\\dstage[12].id.d0\\}
N 16120 6150 16210 6150 {lab=\\dstage[12].id.d0\\}
N 16540 5090 16620 5090 {lab=\\dstage[12].id.d2\\}
N 16620 5090 16620 4550 {lab=\\dstage[12].id.d2\\}
N 16620 4550 16710 4550 {lab=\\dstage[12].id.d2\\}
N 250 4590 16710 4590 {lab=trim[12]}
N 250 4590 440 4590 {lab=trim[12]}
N 440 4590 440 4000 {lab=trim[12]}
N 440 4000 500 4000 {lab=trim[12]}
N 16790 4550 16880 4550 {lab=\\dstage[12].id.out\\}
N 16880 4550 16880 4290 {lab=\\dstage[12].id.out\\}
N 16880 4290 16960 4290 {lab=\\dstage[12].id.out\\}
N 16040 4040 16500 4040 {lab=\\dstage[12].id.out\\}
N 16500 4040 16500 4290 {lab=\\dstage[12].id.out\\}
N 16500 4290 16960 4290 {lab=\\dstage[12].id.out\\}
N 250 6190 16210 6190 {lab=trim[29]}
N 250 6190 440 6190 {lab=trim[29]}
N 440 6190 440 8250 {lab=trim[29]}
N 440 8250 500 8250 {lab=trim[29]}
N 16290 6150 16380 6150 {lab=\\dstage[12].id.d1\\}
N 16380 6150 16380 5090 {lab=\\dstage[12].id.d1\\}
N 16380 5090 16460 5090 {lab=\\dstage[12].id.d1\\}
N 16040 4040 16250 4040 {lab=\\dstage[12].id.d1\\}
N 16250 4040 16250 5090 {lab=\\dstage[12].id.d1\\}
N 16250 5090 16460 5090 {lab=\\dstage[12].id.d1\\}
N 17040 4290 17210 4290 {lab=\\dstage[13].id.ts\\}
N 17040 4290 17210 4290 {lab=\\dstage[13].id.ts\\}
N 17040 4290 17210 4290 {lab=\\dstage[13].id.ts\\}
N 17290 4290 17380 4290 {lab=\\dstage[13].id.d0\\}
N 17380 4290 17380 6400 {lab=\\dstage[13].id.d0\\}
N 17380 6400 17460 6400 {lab=\\dstage[13].id.d0\\}
N 17790 5350 17880 5350 {lab=\\dstage[13].id.d2\\}
N 17880 5350 17880 4800 {lab=\\dstage[13].id.d2\\}
N 17880 4800 17960 4800 {lab=\\dstage[13].id.d2\\}
N 250 4840 17960 4840 {lab=trim[13]}
N 250 4840 440 4840 {lab=trim[13]}
N 440 4840 440 4250 {lab=trim[13]}
N 440 4250 500 4250 {lab=trim[13]}
N 18040 4800 18120 4800 {lab=\\dstage[13].id.out\\}
N 18120 4800 18120 4550 {lab=\\dstage[13].id.out\\}
N 18120 4550 18210 4550 {lab=\\dstage[13].id.out\\}
N 17290 4290 17750 4290 {lab=\\dstage[13].id.out\\}
N 17750 4290 17750 4550 {lab=\\dstage[13].id.out\\}
N 17750 4550 18210 4550 {lab=\\dstage[13].id.out\\}
N 250 6440 17460 6440 {lab=trim[30]}
N 250 6440 440 6440 {lab=trim[30]}
N 440 6440 440 8500 {lab=trim[30]}
N 440 8500 500 8500 {lab=trim[30]}
N 17540 6400 17620 6400 {lab=\\dstage[13].id.d1\\}
N 17620 6400 17620 5350 {lab=\\dstage[13].id.d1\\}
N 17620 5350 17710 5350 {lab=\\dstage[13].id.d1\\}
N 17290 4290 17500 4290 {lab=\\dstage[13].id.d1\\}
N 17500 4290 17500 5350 {lab=\\dstage[13].id.d1\\}
N 17500 5350 17710 5350 {lab=\\dstage[13].id.d1\\}
N 18290 4550 18460 4550 {lab=\\dstage[14].id.ts\\}
N 18290 4550 18460 4550 {lab=\\dstage[14].id.ts\\}
N 18290 4550 18460 4550 {lab=\\dstage[14].id.ts\\}
N 18540 4550 18620 4550 {lab=\\dstage[14].id.d0\\}
N 18620 4550 18620 6650 {lab=\\dstage[14].id.d0\\}
N 18620 6650 18710 6650 {lab=\\dstage[14].id.d0\\}
N 19040 5600 19120 5600 {lab=\\dstage[14].id.d2\\}
N 19120 5600 19120 5050 {lab=\\dstage[14].id.d2\\}
N 19120 5050 19210 5050 {lab=\\dstage[14].id.d2\\}
N 250 5090 19210 5090 {lab=trim[14]}
N 250 5090 440 5090 {lab=trim[14]}
N 440 5090 440 4500 {lab=trim[14]}
N 440 4500 500 4500 {lab=trim[14]}
N 19290 5050 19380 5050 {lab=\\dstage[14].id.out\\}
N 19380 5050 19380 4800 {lab=\\dstage[14].id.out\\}
N 19380 4800 19460 4800 {lab=\\dstage[14].id.out\\}
N 18540 4550 19000 4550 {lab=\\dstage[14].id.out\\}
N 19000 4550 19000 4800 {lab=\\dstage[14].id.out\\}
N 19000 4800 19460 4800 {lab=\\dstage[14].id.out\\}
N 250 6690 18710 6690 {lab=trim[31]}
N 250 6690 460 6690 {lab=trim[31]}
N 460 6690 460 8750 {lab=trim[31]}
N 460 8750 500 8750 {lab=trim[31]}
N 18790 6650 18880 6650 {lab=\\dstage[14].id.d1\\}
N 18880 6650 18880 5600 {lab=\\dstage[14].id.d1\\}
N 18880 5600 18960 5600 {lab=\\dstage[14].id.d1\\}
N 18540 4550 18750 4550 {lab=\\dstage[14].id.d1\\}
N 18750 4550 18750 5600 {lab=\\dstage[14].id.d1\\}
N 18750 5600 18960 5600 {lab=\\dstage[14].id.d1\\}
N 19540 4800 19710 4800 {lab=\\dstage[15].id.ts\\}
N 19540 4800 9860 4800 {lab=\\dstage[15].id.ts\\}
N 9860 4800 9860 250 {lab=\\dstage[15].id.ts\\}
N 9860 250 210 250 {lab=\\dstage[15].id.ts\\}
N 19540 4800 19710 4800 {lab=\\dstage[15].id.ts\\}
N 19790 4800 19880 4800 {lab=\\dstage[15].id.d0\\}
N 19880 4800 19880 6900 {lab=\\dstage[15].id.d0\\}
N 19880 6900 19960 6900 {lab=\\dstage[15].id.d0\\}
N 20290 5850 20380 5850 {lab=\\dstage[15].id.d2\\}
N 20380 5850 20380 5300 {lab=\\dstage[15].id.d2\\}
N 20380 5300 20460 5300 {lab=\\dstage[15].id.d2\\}
N 250 5340 20460 5340 {lab=trim[15]}
N 250 5340 440 5340 {lab=trim[15]}
N 440 5340 440 4750 {lab=trim[15]}
N 440 4750 500 4750 {lab=trim[15]}
N 20540 5300 20640 5300 {lab=\\dstage[15].id.out\\}
N 20640 5300 20640 2770 {lab=\\dstage[15].id.out\\}
N 20640 2770 20710 2770 {lab=\\dstage[15].id.out\\}
N 20540 5300 10480 5300 {lab=\\dstage[15].id.out\\}
N 10480 5300 10480 250 {lab=\\dstage[15].id.out\\}
N 10480 250 460 250 {lab=\\dstage[15].id.out\\}
N 20540 5300 20620 5300 {lab=\\dstage[15].id.out\\}
N 20620 5300 20620 2770 {lab=\\dstage[15].id.out\\}
N 20620 2770 20710 2770 {lab=\\dstage[15].id.out\\}
N 290 250 10520 250 {lab=\\dstage[15].id.out\\}
N 10520 250 10520 2770 {lab=\\dstage[15].id.out\\}
N 10520 2770 20710 2770 {lab=\\dstage[15].id.out\\}
N 290 250 460 250 {lab=\\dstage[15].id.out\\}
N 290 250 10500 250 {lab=\\dstage[15].id.out\\}
N 10500 250 10500 2770 {lab=\\dstage[15].id.out\\}
N 10500 2770 20710 2770 {lab=\\dstage[15].id.out\\}
N 250 6940 19960 6940 {lab=trim[32]}
N 250 6940 460 6940 {lab=trim[32]}
N 460 6940 460 9000 {lab=trim[32]}
N 460 9000 500 9000 {lab=trim[32]}
N 20040 6900 20120 6900 {lab=\\dstage[15].id.d1\\}
N 20120 6900 20120 5850 {lab=\\dstage[15].id.d1\\}
N 20120 5850 20210 5850 {lab=\\dstage[15].id.d1\\}
N 19790 4800 20000 4800 {lab=\\dstage[15].id.d1\\}
N 20000 4800 20000 5850 {lab=\\dstage[15].id.d1\\}
N 20000 5850 20210 5850 {lab=\\dstage[15].id.d1\\}
N 2040 840 2210 840 {lab=\\dstage[1].id.ts\\}
N 2040 840 2210 840 {lab=\\dstage[1].id.ts\\}
N 2040 840 2210 840 {lab=\\dstage[1].id.ts\\}
N 2290 840 2380 840 {lab=\\dstage[1].id.d0\\}
N 2380 840 2380 3170 {lab=\\dstage[1].id.d0\\}
N 2380 3170 2460 3170 {lab=\\dstage[1].id.d0\\}
N 2790 2000 2880 2000 {lab=\\dstage[1].id.d2\\}
N 2880 2000 2880 1630 {lab=\\dstage[1].id.d2\\}
N 2880 1630 2960 1630 {lab=\\dstage[1].id.d2\\}
N 250 1670 2960 1670 {lab=trim[1]}
N 250 1670 380 1670 {lab=trim[1]}
N 380 1670 380 1250 {lab=trim[1]}
N 380 1250 500 1250 {lab=trim[1]}
N 3040 1630 3120 1630 {lab=\\dstage[1].id.out\\}
N 3120 1630 3120 1230 {lab=\\dstage[1].id.out\\}
N 3120 1230 3210 1230 {lab=\\dstage[1].id.out\\}
N 2290 840 2750 840 {lab=\\dstage[1].id.out\\}
N 2750 840 2750 1230 {lab=\\dstage[1].id.out\\}
N 2750 1230 3210 1230 {lab=\\dstage[1].id.out\\}
N 250 3210 2460 3210 {lab=trim[18]}
N 250 3210 200 3210 {lab=trim[18]}
N 200 3210 200 5500 {lab=trim[18]}
N 200 5500 500 5500 {lab=trim[18]}
N 2540 3170 2620 3170 {lab=\\dstage[1].id.d1\\}
N 2620 3170 2620 2000 {lab=\\dstage[1].id.d1\\}
N 2620 2000 2710 2000 {lab=\\dstage[1].id.d1\\}
N 2290 840 2500 840 {lab=\\dstage[1].id.d1\\}
N 2500 840 2500 2000 {lab=\\dstage[1].id.d1\\}
N 2500 2000 2710 2000 {lab=\\dstage[1].id.d1\\}
N 3290 1230 3460 1230 {lab=\\dstage[2].id.ts\\}
N 3290 1230 3460 1230 {lab=\\dstage[2].id.ts\\}
N 3290 1230 3460 1230 {lab=\\dstage[2].id.ts\\}
N 3540 1230 3620 1230 {lab=\\dstage[2].id.d0\\}
N 3620 1230 3620 3490 {lab=\\dstage[2].id.d0\\}
N 3620 3490 3710 3490 {lab=\\dstage[2].id.d0\\}
N 4040 2360 4120 2360 {lab=\\dstage[2].id.d2\\}
N 4120 2360 4120 1930 {lab=\\dstage[2].id.d2\\}
N 4120 1930 4210 1930 {lab=\\dstage[2].id.d2\\}
N 250 1970 4210 1970 {lab=trim[2]}
N 250 1970 380 1970 {lab=trim[2]}
N 380 1970 380 1500 {lab=trim[2]}
N 380 1500 500 1500 {lab=trim[2]}
N 4290 1930 4380 1930 {lab=\\dstage[2].id.out\\}
N 4380 1930 4380 1580 {lab=\\dstage[2].id.out\\}
N 4380 1580 4460 1580 {lab=\\dstage[2].id.out\\}
N 3540 1230 4000 1230 {lab=\\dstage[2].id.out\\}
N 4000 1230 4000 1580 {lab=\\dstage[2].id.out\\}
N 4000 1580 4460 1580 {lab=\\dstage[2].id.out\\}
N 250 3530 3710 3530 {lab=trim[19]}
N 250 3530 220 3530 {lab=trim[19]}
N 220 3530 220 5750 {lab=trim[19]}
N 220 5750 500 5750 {lab=trim[19]}
N 3790 3490 3880 3490 {lab=\\dstage[2].id.d1\\}
N 3880 3490 3880 2360 {lab=\\dstage[2].id.d1\\}
N 3880 2360 3960 2360 {lab=\\dstage[2].id.d1\\}
N 3540 1230 3750 1230 {lab=\\dstage[2].id.d1\\}
N 3750 1230 3750 2360 {lab=\\dstage[2].id.d1\\}
N 3750 2360 3960 2360 {lab=\\dstage[2].id.d1\\}
N 4540 1580 4710 1580 {lab=\\dstage[3].id.ts\\}
N 4540 1580 4710 1580 {lab=\\dstage[3].id.ts\\}
N 4540 1580 4710 1580 {lab=\\dstage[3].id.ts\\}
N 4790 1580 4880 1580 {lab=\\dstage[3].id.d0\\}
N 4880 1580 4880 3790 {lab=\\dstage[3].id.d0\\}
N 4880 3790 4960 3790 {lab=\\dstage[3].id.d0\\}
N 5290 2690 5380 2690 {lab=\\dstage[3].id.d2\\}
N 5380 2690 5380 2220 {lab=\\dstage[3].id.d2\\}
N 5380 2220 5460 2220 {lab=\\dstage[3].id.d2\\}
N 250 2260 5460 2260 {lab=trim[3]}
N 250 2260 400 2260 {lab=trim[3]}
N 400 2260 400 1750 {lab=trim[3]}
N 400 1750 500 1750 {lab=trim[3]}
N 5540 2220 5620 2220 {lab=\\dstage[3].id.out\\}
N 5620 2220 5620 1900 {lab=\\dstage[3].id.out\\}
N 5620 1900 5710 1900 {lab=\\dstage[3].id.out\\}
N 4790 1580 5250 1580 {lab=\\dstage[3].id.out\\}
N 5250 1580 5250 1900 {lab=\\dstage[3].id.out\\}
N 5250 1900 5710 1900 {lab=\\dstage[3].id.out\\}
N 250 3830 4960 3830 {lab=trim[20]}
N 250 3830 240 3830 {lab=trim[20]}
N 240 3830 240 6000 {lab=trim[20]}
N 240 6000 500 6000 {lab=trim[20]}
N 5040 3790 5120 3790 {lab=\\dstage[3].id.d1\\}
N 5120 3790 5120 2690 {lab=\\dstage[3].id.d1\\}
N 5120 2690 5210 2690 {lab=\\dstage[3].id.d1\\}
N 4790 1580 5000 1580 {lab=\\dstage[3].id.d1\\}
N 5000 1580 5000 2690 {lab=\\dstage[3].id.d1\\}
N 5000 2690 5210 2690 {lab=\\dstage[3].id.d1\\}
N 5790 1900 5960 1900 {lab=\\dstage[4].id.ts\\}
N 5790 1900 5960 1900 {lab=\\dstage[4].id.ts\\}
N 5790 1900 5960 1900 {lab=\\dstage[4].id.ts\\}
N 6040 1900 6120 1900 {lab=\\dstage[4].id.d0\\}
N 6120 1900 6120 4070 {lab=\\dstage[4].id.d0\\}
N 6120 4070 6210 4070 {lab=\\dstage[4].id.d0\\}
N 6540 2990 6620 2990 {lab=\\dstage[4].id.d2\\}
N 6620 2990 6620 2490 {lab=\\dstage[4].id.d2\\}
N 6620 2490 6710 2490 {lab=\\dstage[4].id.d2\\}
N 250 2530 6710 2530 {lab=trim[4]}
N 250 2530 400 2530 {lab=trim[4]}
N 400 2530 400 2000 {lab=trim[4]}
N 400 2000 500 2000 {lab=trim[4]}
N 6790 2490 6880 2490 {lab=\\dstage[4].id.out\\}
N 6880 2490 6880 2200 {lab=\\dstage[4].id.out\\}
N 6880 2200 6960 2200 {lab=\\dstage[4].id.out\\}
N 6040 1900 6500 1900 {lab=\\dstage[4].id.out\\}
N 6500 1900 6500 2200 {lab=\\dstage[4].id.out\\}
N 6500 2200 6960 2200 {lab=\\dstage[4].id.out\\}
N 250 4110 6210 4110 {lab=trim[21]}
N 250 4110 280 4110 {lab=trim[21]}
N 280 4110 280 6250 {lab=trim[21]}
N 280 6250 500 6250 {lab=trim[21]}
N 6290 4070 6380 4070 {lab=\\dstage[4].id.d1\\}
N 6380 4070 6380 2990 {lab=\\dstage[4].id.d1\\}
N 6380 2990 6460 2990 {lab=\\dstage[4].id.d1\\}
N 6040 1900 6250 1900 {lab=\\dstage[4].id.d1\\}
N 6250 1900 6250 2990 {lab=\\dstage[4].id.d1\\}
N 6250 2990 6460 2990 {lab=\\dstage[4].id.d1\\}
N 7040 2200 7210 2200 {lab=\\dstage[5].id.ts\\}
N 7040 2200 7210 2200 {lab=\\dstage[5].id.ts\\}
N 7040 2200 7210 2200 {lab=\\dstage[5].id.ts\\}
N 7290 2200 7380 2200 {lab=\\dstage[5].id.d0\\}
N 7380 2200 7380 4350 {lab=\\dstage[5].id.d0\\}
N 7380 4350 7460 4350 {lab=\\dstage[5].id.d0\\}
N 7790 3270 7880 3270 {lab=\\dstage[5].id.d2\\}
N 7880 3270 7880 2760 {lab=\\dstage[5].id.d2\\}
N 7880 2760 7960 2760 {lab=\\dstage[5].id.d2\\}
N 250 2800 7960 2800 {lab=trim[5]}
N 250 2800 380 2800 {lab=trim[5]}
N 380 2800 380 2250 {lab=trim[5]}
N 380 2250 500 2250 {lab=trim[5]}
N 8040 2760 8120 2760 {lab=\\dstage[5].id.out\\}
N 8120 2760 8120 2480 {lab=\\dstage[5].id.out\\}
N 8120 2480 8210 2480 {lab=\\dstage[5].id.out\\}
N 7290 2200 7750 2200 {lab=\\dstage[5].id.out\\}
N 7750 2200 7750 2480 {lab=\\dstage[5].id.out\\}
N 7750 2480 8210 2480 {lab=\\dstage[5].id.out\\}
N 250 4390 7460 4390 {lab=trim[22]}
N 250 4390 300 4390 {lab=trim[22]}
N 300 4390 300 6500 {lab=trim[22]}
N 300 6500 500 6500 {lab=trim[22]}
N 7540 4350 7620 4350 {lab=\\dstage[5].id.d1\\}
N 7620 4350 7620 3270 {lab=\\dstage[5].id.d1\\}
N 7620 3270 7710 3270 {lab=\\dstage[5].id.d1\\}
N 7290 2200 7500 2200 {lab=\\dstage[5].id.d1\\}
N 7500 2200 7500 3270 {lab=\\dstage[5].id.d1\\}
N 7500 3270 7710 3270 {lab=\\dstage[5].id.d1\\}
N 8290 2480 8460 2480 {lab=\\dstage[6].id.ts\\}
N 8290 2480 8460 2480 {lab=\\dstage[6].id.ts\\}
N 8290 2480 8460 2480 {lab=\\dstage[6].id.ts\\}
N 8540 2480 8620 2480 {lab=\\dstage[6].id.d0\\}
N 8620 2480 8620 4610 {lab=\\dstage[6].id.d0\\}
N 8620 4610 8710 4610 {lab=\\dstage[6].id.d0\\}
N 9040 3550 9120 3550 {lab=\\dstage[6].id.d2\\}
N 9120 3550 9120 3020 {lab=\\dstage[6].id.d2\\}
N 9120 3020 9210 3020 {lab=\\dstage[6].id.d2\\}
N 250 3060 9210 3060 {lab=trim[6]}
N 250 3060 400 3060 {lab=trim[6]}
N 400 3060 400 2500 {lab=trim[6]}
N 400 2500 500 2500 {lab=trim[6]}
N 9290 3020 9380 3020 {lab=\\dstage[6].id.out\\}
N 9380 3020 9380 2750 {lab=\\dstage[6].id.out\\}
N 9380 2750 9460 2750 {lab=\\dstage[6].id.out\\}
N 8540 2480 9000 2480 {lab=\\dstage[6].id.out\\}
N 9000 2480 9000 2750 {lab=\\dstage[6].id.out\\}
N 9000 2750 9460 2750 {lab=\\dstage[6].id.out\\}
N 250 4650 8710 4650 {lab=trim[23]}
N 250 4650 320 4650 {lab=trim[23]}
N 320 4650 320 6750 {lab=trim[23]}
N 320 6750 500 6750 {lab=trim[23]}
N 8790 4610 8880 4610 {lab=\\dstage[6].id.d1\\}
N 8880 4610 8880 3550 {lab=\\dstage[6].id.d1\\}
N 8880 3550 8960 3550 {lab=\\dstage[6].id.d1\\}
N 8540 2480 8750 2480 {lab=\\dstage[6].id.d1\\}
N 8750 2480 8750 3550 {lab=\\dstage[6].id.d1\\}
N 8750 3550 8960 3550 {lab=\\dstage[6].id.d1\\}
N 9540 2750 9710 2750 {lab=\\dstage[7].id.ts\\}
N 9540 2750 9710 2750 {lab=\\dstage[7].id.ts\\}
N 9540 2750 9710 2750 {lab=\\dstage[7].id.ts\\}
N 9790 2750 9880 2750 {lab=\\dstage[7].id.d0\\}
N 9880 2750 9880 4880 {lab=\\dstage[7].id.d0\\}
N 9880 4880 9960 4880 {lab=\\dstage[7].id.d0\\}
N 10290 3810 10380 3810 {lab=\\dstage[7].id.d2\\}
N 10380 3810 10380 3280 {lab=\\dstage[7].id.d2\\}
N 10380 3280 10460 3280 {lab=\\dstage[7].id.d2\\}
N 250 3320 10460 3320 {lab=trim[7]}
N 250 3320 400 3320 {lab=trim[7]}
N 400 3320 400 2750 {lab=trim[7]}
N 400 2750 500 2750 {lab=trim[7]}
N 10540 3280 10640 3280 {lab=\\dstage[7].id.out\\}
N 10640 3280 10640 3020 {lab=\\dstage[7].id.out\\}
N 10640 3020 10710 3020 {lab=\\dstage[7].id.out\\}
N 10540 3280 10620 3280 {lab=\\dstage[7].id.out\\}
N 10620 3280 10620 3020 {lab=\\dstage[7].id.out\\}
N 10620 3020 10710 3020 {lab=\\dstage[7].id.out\\}
N 9790 2750 10260 2750 {lab=\\dstage[7].id.out\\}
N 10260 2750 10260 3020 {lab=\\dstage[7].id.out\\}
N 10260 3020 10710 3020 {lab=\\dstage[7].id.out\\}
N 9790 2750 10240 2750 {lab=\\dstage[7].id.out\\}
N 10240 2750 10240 3020 {lab=\\dstage[7].id.out\\}
N 10240 3020 10710 3020 {lab=\\dstage[7].id.out\\}
N 250 4920 9960 4920 {lab=trim[24]}
N 250 4920 340 4920 {lab=trim[24]}
N 340 4920 340 7000 {lab=trim[24]}
N 340 7000 500 7000 {lab=trim[24]}
N 10040 4880 10120 4880 {lab=\\dstage[7].id.d1\\}
N 10120 4880 10120 3810 {lab=\\dstage[7].id.d1\\}
N 10120 3810 10210 3810 {lab=\\dstage[7].id.d1\\}
N 9790 2750 10000 2750 {lab=\\dstage[7].id.d1\\}
N 10000 2750 10000 3810 {lab=\\dstage[7].id.d1\\}
N 10000 3810 10210 3810 {lab=\\dstage[7].id.d1\\}
N 10790 3020 10960 3020 {lab=\\dstage[8].id.ts\\}
N 10790 3020 10960 3020 {lab=\\dstage[8].id.ts\\}
N 10790 3020 10960 3020 {lab=\\dstage[8].id.ts\\}
N 11040 3020 11140 3020 {lab=\\dstage[8].id.d0\\}
N 11140 3020 11140 5130 {lab=\\dstage[8].id.d0\\}
N 11140 5130 11210 5130 {lab=\\dstage[8].id.d0\\}
N 11540 4070 11620 4070 {lab=\\dstage[8].id.d2\\}
N 11620 4070 11620 3540 {lab=\\dstage[8].id.d2\\}
N 11620 3540 11710 3540 {lab=\\dstage[8].id.d2\\}
N 250 3580 11710 3580 {lab=trim[8]}
N 250 3580 400 3580 {lab=trim[8]}
N 400 3580 400 3000 {lab=trim[8]}
N 400 3000 500 3000 {lab=trim[8]}
N 11790 3540 11880 3540 {lab=\\dstage[8].id.out\\}
N 11880 3540 11880 3280 {lab=\\dstage[8].id.out\\}
N 11880 3280 11960 3280 {lab=\\dstage[8].id.out\\}
N 11040 3020 11500 3020 {lab=\\dstage[8].id.out\\}
N 11500 3020 11500 3280 {lab=\\dstage[8].id.out\\}
N 11500 3280 11960 3280 {lab=\\dstage[8].id.out\\}
N 250 5170 11210 5170 {lab=trim[25]}
N 250 5170 380 5170 {lab=trim[25]}
N 380 5170 380 7250 {lab=trim[25]}
N 380 7250 500 7250 {lab=trim[25]}
N 11290 5130 11380 5130 {lab=\\dstage[8].id.d1\\}
N 11380 5130 11380 4070 {lab=\\dstage[8].id.d1\\}
N 11380 4070 11460 4070 {lab=\\dstage[8].id.d1\\}
N 11040 3020 11250 3020 {lab=\\dstage[8].id.d1\\}
N 11250 3020 11250 4070 {lab=\\dstage[8].id.d1\\}
N 11250 4070 11460 4070 {lab=\\dstage[8].id.d1\\}
N 12040 3280 12210 3280 {lab=\\dstage[9].id.ts\\}
N 12040 3280 12210 3280 {lab=\\dstage[9].id.ts\\}
N 12040 3280 12210 3280 {lab=\\dstage[9].id.ts\\}
N 12290 3280 12380 3280 {lab=\\dstage[9].id.d0\\}
N 12380 3280 12380 5390 {lab=\\dstage[9].id.d0\\}
N 12380 5390 12460 5390 {lab=\\dstage[9].id.d0\\}
N 12790 4330 12880 4330 {lab=\\dstage[9].id.d2\\}
N 12880 4330 12880 3790 {lab=\\dstage[9].id.d2\\}
N 12880 3790 12960 3790 {lab=\\dstage[9].id.d2\\}
N 250 3830 12960 3830 {lab=trim[9]}
N 250 3830 420 3830 {lab=trim[9]}
N 420 3830 420 3250 {lab=trim[9]}
N 420 3250 500 3250 {lab=trim[9]}
N 250 5430 12460 5430 {lab=trim[26]}
N 250 5430 400 5430 {lab=trim[26]}
N 400 5430 400 7500 {lab=trim[26]}
N 400 7500 500 7500 {lab=trim[26]}
N 12540 5390 12620 5390 {lab=\\dstage[9].id.d1\\}
N 12620 5390 12620 4330 {lab=\\dstage[9].id.d1\\}
N 12620 4330 12710 4330 {lab=\\dstage[9].id.d1\\}
N 12290 3280 12500 3280 {lab=\\dstage[9].id.d1\\}
N 12500 3280 12500 4330 {lab=\\dstage[9].id.d1\\}
N 12500 4330 12710 4330 {lab=\\dstage[9].id.d1\\}
N 21790 1860 21960 1860 {lab=c[0]}
N 10790 3020 10960 3020 {lab=c[1]}
N 280 500 370 500 {lab=\\iss.one\\}
N 370 500 370 620 {lab=\\iss.one\\}
N 370 620 460 620 {lab=\\iss.one\\}
N 250 2860 440 2860 {lab=reset}
N 250 2860 360 2860 {lab=reset}
N 360 2860 360 660 {lab=reset}
N 360 660 460 660 {lab=reset}
N 250 2860 300 2860 {lab=reset}
N 300 2860 300 750 {lab=reset}
N 300 750 500 750 {lab=reset}
N 250 4740 340 4740 {lab=trim[16]}
N 340 4740 340 2900 {lab=trim[16]}
N 340 2900 440 2900 {lab=trim[16]}
N 250 4740 21460 4740 {lab=trim[16]}
N 250 4740 480 4740 {lab=trim[16]}
N 480 4740 480 5000 {lab=trim[16]}
N 480 5000 500 5000 {lab=trim[16]}
N 20790 2770 20880 2770 {lab=\\iss.d0\\}
N 20880 2770 20880 6010 {lab=\\iss.d0\\}
N 20880 6010 20960 6010 {lab=\\iss.d0\\}
N 21290 4390 21380 4390 {lab=\\iss.d2\\}
N 21380 4390 21380 4700 {lab=\\iss.d2\\}
N 21380 4700 21460 4700 {lab=\\iss.d2\\}
N 250 6050 20960 6050 {lab=trim[33]}
N 250 6050 260 6050 {lab=trim[33]}
N 260 6050 260 9250 {lab=trim[33]}
N 260 9250 500 9250 {lab=trim[33]}
N 21040 6010 21120 6010 {lab=\\iss.d1\\}
N 21120 6010 21120 4390 {lab=\\iss.d1\\}
N 21120 4390 21210 4390 {lab=\\iss.d1\\}
N 20790 2770 21000 2770 {lab=\\iss.d1\\}
N 21000 2770 21000 4390 {lab=\\iss.d1\\}
N 21000 4390 21210 4390 {lab=\\iss.d1\\}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 22250 1860 0 0 {name=X_1_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__buf_1.sym} 11250 3020 0 0 {name=X_2_ VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 750 380 0 0 {name=X\\dstage[0].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 1000 380 0 0 {name=X\\dstage[0].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1750 1300 0 0 {name=X\\dstage[0].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 1250 2810 0 0 {name=X\\dstage[0].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 1000 380 0 0 {name=X\\dstage[0].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 1000 380 0 0 {name=X\\dstage[0].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 1500 1590 0 0 {name=X\\dstage[0].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 13250 3530 0 0 {name=X\\dstage[10].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 13500 3530 0 0 {name=X\\dstage[10].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 14250 4040 0 0 {name=X\\dstage[10].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13750 5640 0 0 {name=X\\dstage[10].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 13500 3530 0 0 {name=X\\dstage[10].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 13500 3530 0 0 {name=X\\dstage[10].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 14000 4590 0 0 {name=X\\dstage[10].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 14500 3790 0 0 {name=X\\dstage[11].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 14750 3790 0 0 {name=X\\dstage[11].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15500 4300 0 0 {name=X\\dstage[11].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 15000 5890 0 0 {name=X\\dstage[11].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 14750 3790 0 0 {name=X\\dstage[11].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 14750 3790 0 0 {name=X\\dstage[11].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 15250 4840 0 0 {name=X\\dstage[11].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 15750 4040 0 0 {name=X\\dstage[12].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 16000 4040 0 0 {name=X\\dstage[12].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16750 4550 0 0 {name=X\\dstage[12].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 16250 6150 0 0 {name=X\\dstage[12].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 16000 4040 0 0 {name=X\\dstage[12].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 16000 4040 0 0 {name=X\\dstage[12].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 16500 5090 0 0 {name=X\\dstage[12].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 17000 4290 0 0 {name=X\\dstage[13].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 17250 4290 0 0 {name=X\\dstage[13].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 18000 4800 0 0 {name=X\\dstage[13].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 17500 6400 0 0 {name=X\\dstage[13].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 17250 4290 0 0 {name=X\\dstage[13].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 17250 4290 0 0 {name=X\\dstage[13].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 17750 5350 0 0 {name=X\\dstage[13].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 18250 4550 0 0 {name=X\\dstage[14].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 18500 4550 0 0 {name=X\\dstage[14].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 19250 5050 0 0 {name=X\\dstage[14].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 18750 6650 0 0 {name=X\\dstage[14].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 18500 4550 0 0 {name=X\\dstage[14].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 18500 4550 0 0 {name=X\\dstage[14].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 19000 5600 0 0 {name=X\\dstage[14].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 19500 4800 0 0 {name=X\\dstage[15].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 19750 4800 0 0 {name=X\\dstage[15].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 20500 5300 0 0 {name=X\\dstage[15].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 20000 6900 0 0 {name=X\\dstage[15].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 250 250 0 0 {name=X\\dstage[15].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 19750 4800 0 0 {name=X\\dstage[15].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 20250 5850 0 0 {name=X\\dstage[15].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 2000 840 0 0 {name=X\\dstage[1].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 2250 840 0 0 {name=X\\dstage[1].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3000 1630 0 0 {name=X\\dstage[1].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 2500 3170 0 0 {name=X\\dstage[1].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 2250 840 0 0 {name=X\\dstage[1].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 2250 840 0 0 {name=X\\dstage[1].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 2750 2000 0 0 {name=X\\dstage[1].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 3250 1230 0 0 {name=X\\dstage[2].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 3500 1230 0 0 {name=X\\dstage[2].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 4250 1930 0 0 {name=X\\dstage[2].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 3750 3490 0 0 {name=X\\dstage[2].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 3500 1230 0 0 {name=X\\dstage[2].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 3500 1230 0 0 {name=X\\dstage[2].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 4000 2360 0 0 {name=X\\dstage[2].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 4500 1580 0 0 {name=X\\dstage[3].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 4750 1580 0 0 {name=X\\dstage[3].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5500 2220 0 0 {name=X\\dstage[3].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 5000 3790 0 0 {name=X\\dstage[3].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 4750 1580 0 0 {name=X\\dstage[3].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 4750 1580 0 0 {name=X\\dstage[3].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 5250 2690 0 0 {name=X\\dstage[3].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 5750 1900 0 0 {name=X\\dstage[4].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 6000 1900 0 0 {name=X\\dstage[4].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6750 2490 0 0 {name=X\\dstage[4].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 6250 4070 0 0 {name=X\\dstage[4].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 6000 1900 0 0 {name=X\\dstage[4].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 6000 1900 0 0 {name=X\\dstage[4].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 6500 2990 0 0 {name=X\\dstage[4].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 7000 2200 0 0 {name=X\\dstage[5].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 7250 2200 0 0 {name=X\\dstage[5].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8000 2760 0 0 {name=X\\dstage[5].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 7500 4350 0 0 {name=X\\dstage[5].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 7250 2200 0 0 {name=X\\dstage[5].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 7250 2200 0 0 {name=X\\dstage[5].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 7750 3270 0 0 {name=X\\dstage[5].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 8250 2480 0 0 {name=X\\dstage[6].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 8500 2480 0 0 {name=X\\dstage[6].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 9250 3020 0 0 {name=X\\dstage[6].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 8750 4610 0 0 {name=X\\dstage[6].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 8500 2480 0 0 {name=X\\dstage[6].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 8500 2480 0 0 {name=X\\dstage[6].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 9000 3550 0 0 {name=X\\dstage[6].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 9500 2750 0 0 {name=X\\dstage[7].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 9750 2750 0 0 {name=X\\dstage[7].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10500 3280 0 0 {name=X\\dstage[7].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 10000 4880 0 0 {name=X\\dstage[7].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 9750 2750 0 0 {name=X\\dstage[7].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 9750 2750 0 0 {name=X\\dstage[7].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 10250 3810 0 0 {name=X\\dstage[7].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 10750 3020 0 0 {name=X\\dstage[8].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 11000 3020 0 0 {name=X\\dstage[8].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11750 3540 0 0 {name=X\\dstage[8].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 11250 5130 0 0 {name=X\\dstage[8].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 11000 3020 0 0 {name=X\\dstage[8].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 11000 3020 0 0 {name=X\\dstage[8].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 11500 4070 0 0 {name=X\\dstage[8].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_2.sym} 12000 3280 0 0 {name=X\\dstage[9].id.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 12250 3280 0 0 {name=X\\dstage[9].id.delaybuf1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 13000 3790 0 0 {name=X\\dstage[9].id.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 12500 5390 0 0 {name=X\\dstage[9].id.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 12250 3280 0 0 {name=X\\dstage[9].id.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 12250 3280 0 0 {name=X\\dstage[9].id.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 12750 4330 0 0 {name=X\\dstage[9].id.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 21750 1860 0 0 {name=Xibufp00 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 22000 1860 0 0 {name=Xibufp01 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_2.sym} 10750 3020 0 0 {name=Xibufp10 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_8.sym} 11000 3020 0 0 {name=Xibufp11 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__conb_1.sym} 250 500 0 0 {name=X\\iss.const1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__or2_2.sym} 500 2880 0 0 {name=X\\iss.ctrlen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkbuf_1.sym} 20750 2770 0 0 {name=X\\iss.delaybuf0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 21500 4700 0 0 {name=X\\iss.delayen0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_2.sym} 21000 6010 0 0 {name=X\\iss.delayen1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_8.sym} 500 250 0 0 {name=X\\iss.delayenb0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvn_4.sym} 20750 2770 0 0 {name=X\\iss.delayenb1 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__clkinv_1.sym} 21250 4390 0 0 {name=X\\iss.delayint0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__einvp_1.sym} 500 620 0 0 {name=X\\iss.reseten0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 750 0 0 {name=Xantenna_0 VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 9250 0 0 {name=Xantenna_1[33] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 9000 0 0 {name=Xantenna_1[32] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 8750 0 0 {name=Xantenna_1[31] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 8500 0 0 {name=Xantenna_1[30] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 8250 0 0 {name=Xantenna_1[29] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 8000 0 0 {name=Xantenna_1[28] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 7750 0 0 {name=Xantenna_1[27] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 7500 0 0 {name=Xantenna_1[26] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 7250 0 0 {name=Xantenna_1[25] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 7000 0 0 {name=Xantenna_1[24] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6750 0 0 {name=Xantenna_1[23] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6500 0 0 {name=Xantenna_1[22] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6250 0 0 {name=Xantenna_1[21] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 6000 0 0 {name=Xantenna_1[20] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5750 0 0 {name=Xantenna_1[19] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5500 0 0 {name=Xantenna_1[18] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5250 0 0 {name=Xantenna_1[17] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 5000 0 0 {name=Xantenna_1[16] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4750 0 0 {name=Xantenna_1[15] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4500 0 0 {name=Xantenna_1[14] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4250 0 0 {name=Xantenna_1[13] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 4000 0 0 {name=Xantenna_1[12] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3750 0 0 {name=Xantenna_1[11] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3500 0 0 {name=Xantenna_1[10] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3250 0 0 {name=Xantenna_1[9] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 3000 0 0 {name=Xantenna_1[8] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2750 0 0 {name=Xantenna_1[7] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2500 0 0 {name=Xantenna_1[6] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2250 0 0 {name=Xantenna_1[5] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 2000 0 0 {name=Xantenna_1[4] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1750 0 0 {name=Xantenna_1[3] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1500 0 0 {name=Xantenna_1[2] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1250 0 0 {name=Xantenna_1[1] VCCPIN=vcc VSSPIN=gnd}
C {skywater130/sky130_fd_sc_ms__diode_2.sym} 500 1000 0 0 {name=Xantenna_1[0] VCCPIN=vcc VSSPIN=gnd}
C {devices/opin.sym} 22500 1860 0 0 {lab=clockp[0]}
C {devices/opin.sym} 11500 3020 0 0 {lab=clockp[1]}
C {devices/ipin.sym} 250 2860 0 0 {lab=reset}
C {devices/ipin.sym} 250 1340 0 0 {lab=trim[0]}
C {devices/ipin.sym} 250 1670 0 0 {lab=trim[1]}
C {devices/ipin.sym} 250 1970 0 0 {lab=trim[2]}
C {devices/ipin.sym} 250 2260 0 0 {lab=trim[3]}
C {devices/ipin.sym} 250 2530 0 0 {lab=trim[4]}
C {devices/ipin.sym} 250 2800 0 0 {lab=trim[5]}
C {devices/ipin.sym} 250 3060 0 0 {lab=trim[6]}
C {devices/ipin.sym} 250 3320 0 0 {lab=trim[7]}
C {devices/ipin.sym} 250 3580 0 0 {lab=trim[8]}
C {devices/ipin.sym} 250 3830 0 0 {lab=trim[9]}
C {devices/ipin.sym} 250 4080 0 0 {lab=trim[10]}
C {devices/ipin.sym} 250 4340 0 0 {lab=trim[11]}
C {devices/ipin.sym} 250 4590 0 0 {lab=trim[12]}
C {devices/ipin.sym} 250 4840 0 0 {lab=trim[13]}
C {devices/ipin.sym} 250 5090 0 0 {lab=trim[14]}
C {devices/ipin.sym} 250 5340 0 0 {lab=trim[15]}
C {devices/ipin.sym} 250 4740 0 0 {lab=trim[16]}
C {devices/ipin.sym} 250 2850 0 0 {lab=trim[17]}
C {devices/ipin.sym} 250 3210 0 0 {lab=trim[18]}
C {devices/ipin.sym} 250 3530 0 0 {lab=trim[19]}
C {devices/ipin.sym} 250 3830 0 0 {lab=trim[20]}
C {devices/ipin.sym} 250 4110 0 0 {lab=trim[21]}
C {devices/ipin.sym} 250 4390 0 0 {lab=trim[22]}
C {devices/ipin.sym} 250 4650 0 0 {lab=trim[23]}
C {devices/ipin.sym} 250 4920 0 0 {lab=trim[24]}
C {devices/ipin.sym} 250 5170 0 0 {lab=trim[25]}
C {devices/ipin.sym} 250 5430 0 0 {lab=trim[26]}
C {devices/ipin.sym} 250 5680 0 0 {lab=trim[27]}
C {devices/ipin.sym} 250 5930 0 0 {lab=trim[28]}
C {devices/ipin.sym} 250 6190 0 0 {lab=trim[29]}
C {devices/ipin.sym} 250 6440 0 0 {lab=trim[30]}
C {devices/ipin.sym} 250 6690 0 0 {lab=trim[31]}
C {devices/ipin.sym} 250 6940 0 0 {lab=trim[32]}
C {devices/ipin.sym} 250 6050 0 0 {lab=trim[33]}
