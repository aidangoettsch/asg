v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
C {osu035_xschem/NOR2X1.sym} 250 250 0 0 {name=X_7_ VCCPIN=vcc VSSPIN=gnd
C {osu035_xschem/BUFX2.sym} 250 500 0 0 {name=X_10_ VCCPIN=vcc VSSPIN=gnd
C {osu035_xschem/NAND2X1.sym} 250 750 0 0 {name=X_9_ VCCPIN=vcc VSSPIN=gnd
C {osu035_xschem/NOR2X1.sym} 250 1000 0 0 {name=X_6_ VCCPIN=vcc VSSPIN=gnd
C {osu035_xschem/NAND2X1.sym} 250 1250 0 0 {name=X_8_ VCCPIN=vcc VSSPIN=gnd
C {osu035_xschem/OAI22X1.sym} 250 1500 0 0 {name=X_5_ VCCPIN=vcc VSSPIN=gnd
